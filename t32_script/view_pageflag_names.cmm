v.v %HEX %STRING pageflag_names