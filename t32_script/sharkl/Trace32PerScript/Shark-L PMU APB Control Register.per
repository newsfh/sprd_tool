;This file is generated by Trace32PerBuilder Version: 0.5.3.
;  Please access external network Trace32 Per Builder Homepage for documents
;and source code.
;   http://wikiserver.spreadtrum.com/Projects/SoftwareSystem/wiki/BbDrvTools/Trace32PerBuilder

config 10. 8.
width 35.
TREE.open "SharkL - AON_TOP - pmu_apb_rf"
  BASE sd:0x402B0000
  GROUP.LONG 0x0000++0x3 "0x402B0000 + 0x0000"
    LINE.LONG 0x00 "PD_CA7_TOP_CFG"
      BITFLD.LONG 0x00 29.--31. "  Reserved                    , " "Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved"
      BITFLD.LONG 0x00 28. "                                                       PD_CA7_TOP_DBG_SHUTDOWN_EN , For debug purpose." "0,1"
      BITFLD.LONG 0x00 26.--27. "  Reserved                  , " "Reserved,Reserved,Reserved,Reserved"
      BITFLD.LONG 0x00 25. "  PD_CA7_TOP_FORCE_SHUTDOWN , Force Power Domain 'PD_CA7_TOP' SHUTDOWN. Only effective when 'PD_CA7_TOP_AUTO_SHUTDOWN_EN' de-asserted." "0,1"
      TEXTLINE "                                            "
      BITFLD.LONG 0x00 24. "  PD_CA7_TOP_AUTO_SHUTDOWN_EN , Enable Power Domain 'PD_CA7_TOP' automatically Power-off when AP into Deep Sleep. 0 :  Power Domain SHUTDOWN by 'PD_CA7_TOP_FORCE_SHUTDOWN'; 1 : Power domain Automatically SHUTDOWN when AP enter Deep Sleep;" "Power Domain SHUTDOWN by 'PD_CA,Power domain Automatically SHUTDOWN when AP enter Deep Sleep;"
      BITFLD.LONG 0x00 16.--23. "  PD_CA7_TOP_PWR_ON_DLY      , Delay time for  'PD_CA7_TOP'  from turn on power switch to asserting power reset,  in power up process, with unit of 30us." "none"
      BITFLD.LONG 0x00 8.--15. "   PD_CA7_TOP_PWR_ON_SEQ_DLY , Delay time for  'PD_CA7_TOP'  from Powering up,  in power up process, with unit of 30us." "none"
      BITFLD.LONG 0x00 0.--7. "          PD_CA7_TOP_ISO_ON_DLY     , Delay time for  'PD_CA7_TOP'  from enable isolation cell to turn-off power switch, in power down process. with unit of 30us." "none"
      TEXTLINE "                                            "
  GROUP.LONG 0x0004++0x3 "0x402B0000 + 0x0004"
    LINE.LONG 0x00 "PD_CA7_C0_CFG"
      BITFLD.LONG 0x00 30.--31. "  Reserved                 , " "Reserved,Reserved,Reserved,Reserved"
      BITFLD.LONG 0x00 29. "  PD_CA7_C0_WFI_SHUTDOWN_EN  , " "0,1"
      BITFLD.LONG 0x00 28. "                                                              PD_CA7_C0_DBG_SHUTDOWN_EN , For debug purpose." "0,1"
      BITFLD.LONG 0x00 26.--27. "  Reserved                 , " "Reserved,Reserved,Reserved,Reserved"
      TEXTLINE "                                            "
      BITFLD.LONG 0x00 25. "  PD_CA7_C0_FORCE_SHUTDOWN , Force Power Domain 'PD_CA7_C0' SHUTDOWN. Only effective when 'PD_CA7_C0_AUTO_SHUTDOWN_EN' de-asserted." "0,1"
      BITFLD.LONG 0x00 24. "         PD_CA7_C0_AUTO_SHUTDOWN_EN , Enable Power Domain 'PD_CA7_C0' automatically Power-off when AP into Deep Sleep. 0 :  Power Domain SHUTDOWN by 'PD_CA7_C0_FORCE_SHUTDOWN'; 1 : Power domain Automatically SHUTDOWN when AP enter Deep Sleep;" "Power Domain SHUTDOWN by 'PD_CA,Power domain Automatically SHUTDOWN when AP enter Deep Sleep;"
      BITFLD.LONG 0x00 16.--23. "  PD_CA7_C0_PWR_ON_DLY      , Delay time for  'PD_CA7_C0'  from turn power switch to asserting power reset,  in power up process, with unit of 30us." "none"
      BITFLD.LONG 0x00 8.--15. "   PD_CA7_C0_PWR_ON_SEQ_DLY , Delay time for  'PD_CA7_C0'  from Powering up,  in power up process, with unit of 30us." "none"
      TEXTLINE "                                            "
      BITFLD.LONG 0x00 0.--7. "  PD_CA7_C0_ISO_ON_DLY     , Delay time for  'PD_CA7_C0'  from enable isolation cell to turn-off power switch, in power on process. with unit of 30us." "none"
  GROUP.LONG 0x0008++0x3 "0x402B0000 + 0x0008"
    LINE.LONG 0x00 "PD_CA7_C1_CFG"
      BITFLD.LONG 0x00 30.--31. "  Reserved                 , " "Reserved,Reserved,Reserved,Reserved"
      BITFLD.LONG 0x00 29. "  PD_CA7_C1_WFI_SHUTDOWN_EN  , " "0,1"
      BITFLD.LONG 0x00 28. "                                                              PD_CA7_C1_DBG_SHUTDOWN_EN , For debug purpose." "0,1"
      BITFLD.LONG 0x00 26.--27. "  Reserved                 , " "Reserved,Reserved,Reserved,Reserved"
      TEXTLINE "                                            "
      BITFLD.LONG 0x00 25. "  PD_CA7_C1_FORCE_SHUTDOWN , Force Power Domain 'PD_CA7_C1' SHUTDOWN. Only effective when 'PD_CA7_C1_AUTO_SHUTDOWN_EN' de-asserted." "0,1"
      BITFLD.LONG 0x00 24. "         PD_CA7_C1_AUTO_SHUTDOWN_EN , Enable Power Domain 'PD_CA7_C1' automatically Power-off when AP into Deep Sleep. 0 :  Power Domain SHUTDOWN by 'PD_CA7_C1_FORCE_SHUTDOWN'; 1 : Power domain Automatically SHUTDOWN when AP enter Deep Sleep;" "Power Domain SHUTDOWN by 'PD_CA,Power domain Automatically SHUTDOWN when AP enter Deep Sleep;"
      BITFLD.LONG 0x00 16.--23. "  PD_CA7_C1_PWR_ON_DLY      , Delay time for  'PD_CA7_C1'  from turn power switch to asserting power reset,  in power up process, with unit of 30us." "none"
      BITFLD.LONG 0x00 8.--15. "   PD_CA7_C1_PWR_ON_SEQ_DLY , Delay time for  'PD_CA7_C1'  from Powering up,  in power up process, with unit of 30us." "none"
      TEXTLINE "                                            "
      BITFLD.LONG 0x00 0.--7. "  PD_CA7_C1_ISO_ON_DLY     , Delay time for  'PD_CA7_C1'  from enable isolation cell to turn-off power switch, in power on process. with unit of 30us." "none"
  GROUP.LONG 0x000C++0x3 "0x402B0000 + 0x000C"
    LINE.LONG 0x00 "PD_CA7_C2_CFG"
      BITFLD.LONG 0x00 30.--31. "  Reserved                 , " "Reserved,Reserved,Reserved,Reserved"
      BITFLD.LONG 0x00 29. "  PD_CA7_C2_WFI_SHUTDOWN_EN  , " "0,1"
      BITFLD.LONG 0x00 28. "                                                              PD_CA7_C2_DBG_SHUTDOWN_EN , For debug purpose." "0,1"
      BITFLD.LONG 0x00 26.--27. "  Reserved                 , " "Reserved,Reserved,Reserved,Reserved"
      TEXTLINE "                                            "
      BITFLD.LONG 0x00 25. "  PD_CA7_C2_FORCE_SHUTDOWN , Force Power Domain 'PD_CA7_C2' SHUTDOWN. Only effective when 'PD_CA7_C2_AUTO_SHUTDOWN_EN' de-asserted." "0,1"
      BITFLD.LONG 0x00 24. "         PD_CA7_C2_AUTO_SHUTDOWN_EN , Enable Power Domain 'PD_CA7_C2' automatically Power-off when AP into Deep Sleep. 0 :  Power Domain SHUTDOWN by 'PD_CA7_C2_FORCE_SHUTDOWN'; 1 : Power domain Automatically SHUTDOWN when AP enter Deep Sleep;" "Power Domain SHUTDOWN by 'PD_CA,Power domain Automatically SHUTDOWN when AP enter Deep Sleep;"
      BITFLD.LONG 0x00 16.--23. "  PD_CA7_C2_PWR_ON_DLY      , Delay time for  'PD_CA7_C2'  from turn power switch to asserting power reset,  in power up process, with unit of 30us." "none"
      BITFLD.LONG 0x00 8.--15. "   PD_CA7_C2_PWR_ON_SEQ_DLY , Delay time for  'PD_CA7_C2'  from Powering up,  in power up process, with unit of 30us." "none"
      TEXTLINE "                                            "
      BITFLD.LONG 0x00 0.--7. "  PD_CA7_C2_ISO_ON_DLY     , Delay time for  'PD_CA7_C2'  from enable isolation cell to turn-off power switch, in power on process. with unit of 30us." "none"
  GROUP.LONG 0x0010++0x3 "0x402B0000 + 0x0010"
    LINE.LONG 0x00 "PD_CA7_C3_CFG"
      BITFLD.LONG 0x00 30.--31. "  Reserved                 , " "Reserved,Reserved,Reserved,Reserved"
      BITFLD.LONG 0x00 29. "  PD_CA7_C3_WFI_SHUTDOWN_EN  , " "0,1"
      BITFLD.LONG 0x00 28. "                                                              PD_CA7_C3_DBG_SHUTDOWN_EN , For debug purpose." "0,1"
      BITFLD.LONG 0x00 26.--27. "  Reserved                 , " "Reserved,Reserved,Reserved,Reserved"
      TEXTLINE "                                            "
      BITFLD.LONG 0x00 25. "  PD_CA7_C3_FORCE_SHUTDOWN , Force Power Domain 'PD_CA7_C3' SHUTDOWN. Only effective when 'PD_CA7_C3_AUTO_SHUTDOWN_EN' de-asserted." "0,1"
      BITFLD.LONG 0x00 24. "         PD_CA7_C3_AUTO_SHUTDOWN_EN , Enable Power Domain 'PD_CA7_C3' automatically Power-off when AP into Deep Sleep. 0 :  Power Domain SHUTDOWN by 'PD_CA7_C3_FORCE_SHUTDOWN'; 1 : Power domain Automatically SHUTDOWN when AP enter Deep Sleep;" "Power Domain SHUTDOWN by 'PD_CA,Power domain Automatically SHUTDOWN when AP enter Deep Sleep;"
      BITFLD.LONG 0x00 16.--23. "  PD_CA7_C3_PWR_ON_DLY      , Delay time for  'PD_CA7_C3'  from turn power switch to asserting power reset,  in power up process, with unit of 30us." "none"
      BITFLD.LONG 0x00 8.--15. "   PD_CA7_C3_PWR_ON_SEQ_DLY , Delay time for  'PD_CA7_C3'  from Powering up,  in power up process, with unit of 30us." "none"
      TEXTLINE "                                            "
      BITFLD.LONG 0x00 0.--7. "  PD_CA7_C3_ISO_ON_DLY     , Delay time for  'PD_CA7_C3'  from enable isolation cell to turn-off power switch, in power on process. with unit of 30us." "none"
  GROUP.LONG 0x0018++0x3 "0x402B0000 + 0x0018"
    LINE.LONG 0x00 "PD_AP_SYS_CFG"
      BITFLD.LONG 0x00 26.--31. "  Reserved                 , " "Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved"
      BITFLD.LONG 0x00 25. "  PD_AP_SYS_FORCE_SHUTDOWN , Force Power Domain 'PD_AP_SYS' SHUTDOWN. Only effective when 'PD_AP_SYS_AUTO_SHUTDOWN_EN' de-asserted." "0,1"
      BITFLD.LONG 0x00 24. "  PD_AP_SYS_AUTO_SHUTDOWN_EN , Enable Power Domain 'PD_AP_SYS' automatically Power-off when AP into Deep Sleep. 0 :  Power Domain SHUTDOWN by 'PD_AP_SYS_FORCE_SHUTDOWN'; 1 : Power domain Automatically SHUTDOWN when AP enter Deep Sleep;" "Power Domain SHUTDOWN by 'PD_AP_SYS_FORCE_SHUTDOWN';,Power domain Automatically SHUTDOWN when AP enter Deep Sleep;"
      BITFLD.LONG 0x00 16.--23. "  PD_AP_SYS_PWR_ON_DLY , Delay time for  'PD_AP_SYS'  from turn power switch to asserting power reset,  in power up process, with unit of 30us." "none"
      TEXTLINE "                                            "
      BITFLD.LONG 0x00 8.--15. "  PD_AP_SYS_PWR_ON_SEQ_DLY , Delay time for  'PD_AP_SYS'  from Powering up,  in power up process, with unit of 30us." "none"
      BITFLD.LONG 0x00 0.--7. "          PD_AP_SYS_ISO_ON_DLY     , Delay time for  'PD_AP_SYS'  from enable isolation cell to turn-off power switch, in power on process. with unit of 30us." "none"
  GROUP.LONG 0x001C++0x3 "0x402B0000 + 0x001C"
    LINE.LONG 0x00 "PD_MM_TOP_CFG"
      BITFLD.LONG 0x00 26.--31. "  Reserved                 , " "Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved"
      BITFLD.LONG 0x00 25. "  PD_MM_TOP_FORCE_SHUTDOWN , Force Power Domain 'PD_MM_TOP' SHUTDOWN. Only effective when 'PD_MM_TOP_AUTO_SHUTDOWN_EN' de-asserted." "0,1"
      BITFLD.LONG 0x00 24. "  PD_MM_TOP_AUTO_SHUTDOWN_EN , Enable Power Domain 'PD_MM_TOP' automatically Power-off when AP into Deep Sleep. 0 :  Power Domain SHUTDOWN by 'PD_MM_TOP_FORCE_SHUTDOWN'; 1 : Power domain Automatically SHUTDOWN when AP enter Deep Sleep;" "Power Domain SHUTDOWN by 'PD_MM_TOP_FORCE_SHUTDOWN';,Power domain Automatically SHUTDOWN when AP enter Deep Sleep;"
      BITFLD.LONG 0x00 16.--23. "  PD_MM_TOP_PWR_ON_DLY , Delay time for  'PD_MM_TOP'  from turn power switch to asserting power reset,  in power up process, with unit of 30us." "none"
      TEXTLINE "                                            "
      BITFLD.LONG 0x00 8.--15. "  PD_MM_TOP_PWR_ON_SEQ_DLY , Delay time for  'PD_MM_TOP'  from Powering up,  in power up process, with unit of 30us." "none"
      BITFLD.LONG 0x00 0.--7. "          PD_MM_TOP_ISO_ON_DLY     , Delay time for  'PD_MM_TOP'  from enable isolation cell to turn-off power switch, in power on process. with unit of 30us." "none"
  GROUP.LONG 0x0020++0x3 "0x402B0000 + 0x0020"
    LINE.LONG 0x00 "PD_GPU_TOP_CFG"
      BITFLD.LONG 0x00 26.--31. "  Reserved                  , " "Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved"
      BITFLD.LONG 0x00 25. "  PD_GPU_TOP_FORCE_SHUTDOWN , Force Power Domain 'PD_GPU_TOP' SHUTDOWN. Only effective when 'PD_GPU_TOP_AUTO_SHUTDOWN_EN' de-asserted." "0,1"
      BITFLD.LONG 0x00 24. "  PD_GPU_TOP_AUTO_SHUTDOWN_EN , Enable Power Domain 'PD_GPU_TOP' automatically Power-off when AP into Deep Sleep. 0 :  Power Domain SHUTDOWN by 'PD_GPU_TOP_FORCE_SHUTDOWN'; 1 : Power domain Automatically SHUTDOWN when AP enter Deep Sleep;" "Power Domain SHUTDOWN by 'PD_GPU_TOP_FORCE_SHUTDOWN';,Power domain Automatically SHUTDOWN when AP enter Deep Sleep;"
      BITFLD.LONG 0x00 16.--23. "  PD_GPU_TOP_PWR_ON_DLY , Delay time for  'PD_GPU_TOP'  from turn power switch to asserting power reset,  in power up process, with unit of 30us." "none"
      TEXTLINE "                                            "
      BITFLD.LONG 0x00 8.--15. "  PD_GPU_TOP_PWR_ON_SEQ_DLY , Delay time for  'PD_GPU_TOP'  from Powering up,  in power up process, with unit of 30us." "none"
      BITFLD.LONG 0x00 0.--7. "          PD_GPU_TOP_ISO_ON_DLY     , Delay time for  'PD_GPU_TOP'  from enable isolation cell to turn-off power switch, in power on process. with unit of 30us." "none"
  GROUP.LONG 0x0024++0x3 "0x402B0000 + 0x0024"
    LINE.LONG 0x00 "PD_CP0_ARM9_0_CFG"
      BITFLD.LONG 0x00 26.--31. "  Reserved                     , " "Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved"
      BITFLD.LONG 0x00 25. "  PD_CP0_ARM9_0_FORCE_SHUTDOWN , Force Power Domain 'PD_CP0_ARM9_0' SHUTDOWN. Only effective when 'PD_CP0_ARM9_0_AUTO_SHUTDOWN_EN' de-asserted." "0,1"
      BITFLD.LONG 0x00 24. "  PD_CP0_ARM9_0_AUTO_SHUTDOWN_EN , Enable Power Domain 'PD_CP0_ARM9_0' automatically Power-off when AP into Deep Sleep. 0 :  Power Domain SHUTDOWN by 'PD_CP0_ARM9_0_FORCE_SHUTDOWN'; 1 : Power domain Automatically SHUTDOWN when AP enter Deep Sleep;" "Power Domain SHUTDOWN by 'PD_CP,Power domain Automatically SHUTDOWN when AP enter Deep Sleep;"
      BITFLD.LONG 0x00 16.--23. "  PD_CP0_ARM9_0_PWR_ON_DLY , Delay time for  'PD_CP0_ARM9_0'  from turn power switch to asserting power reset,  in power up process, with unit of 30us." "none"
      TEXTLINE "                                            "
      BITFLD.LONG 0x00 8.--15. "  PD_CP0_ARM9_0_PWR_ON_SEQ_DLY , Delay time for  'PD_CP0_ARM9_0'  from Powering up,  in power up process, with unit of 30us." "none"
      BITFLD.LONG 0x00 0.--7. "          PD_CP0_ARM9_0_ISO_ON_DLY     , Delay time for  'PD_CP0_ARM9_0'  from enable isolation cell to turn-off power switch, in power on process. with unit of 30us." "none"
  GROUP.LONG 0x0028++0x3 "0x402B0000 + 0x0028"
    LINE.LONG 0x00 "PD_CP0_ARM9_1_CFG"
      BITFLD.LONG 0x00 26.--31. "  Reserved                     , " "Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved"
      BITFLD.LONG 0x00 25. "  PD_CP0_ARM9_1_FORCE_SHUTDOWN , Force Power Domain 'PD_CP0_ARM9_1' SHUTDOWN. Only effective when 'PD_CP0_ARM9_1_AUTO_SHUTDOWN_EN' de-asserted." "0,1"
      BITFLD.LONG 0x00 24. "  PD_CP0_ARM9_1_AUTO_SHUTDOWN_EN , Enable Power Domain 'PD_CP0_ARM9_1' automatically Power-off when AP into Deep Sleep. 0 :  Power Domain SHUTDOWN by 'PD_CP0_ARM9_1_FORCE_SHUTDOWN'; 1 : Power domain Automatically SHUTDOWN when AP enter Deep Sleep;" "Power Domain SHUTDOWN by 'PD_CP,Power domain Automatically SHUTDOWN when AP enter Deep Sleep;"
      BITFLD.LONG 0x00 16.--23. "  PD_CP0_ARM9_1_PWR_ON_DLY , Delay time for  'PD_CP0_ARM9_1'  from turn power switch to asserting power reset,  in power up process, with unit of 30us." "none"
      TEXTLINE "                                            "
      BITFLD.LONG 0x00 8.--15. "  PD_CP0_ARM9_1_PWR_ON_SEQ_DLY , Delay time for  'PD_CP0_ARM9_1'  from Powering up,  in power up process, with unit of 30us." "none"
      BITFLD.LONG 0x00 0.--7. "          PD_CP0_ARM9_1_ISO_ON_DLY     , Delay time for  'PD_CP0_ARM9_1'  from enable isolation cell to turn-off power switch, in power on process. with unit of 30us." "none"
  GROUP.LONG 0x002C++0x3 "0x402B0000 + 0x002C"
    LINE.LONG 0x00 "PD_CP0_HU3GE_CFG"
      BITFLD.LONG 0x00 26.--31. "  Reserved                    , " "Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved"
      BITFLD.LONG 0x00 25. "  PD_CP0_HU3GE_FORCE_SHUTDOWN , Force Power Domain 'PD_CP0_HU3GE' SHUTDOWN. Only effective when 'PD_CP0_HU3GE_AUTO_SHUTDOWN_EN' de-asserted." "0,1"
      BITFLD.LONG 0x00 24. "  PD_CP0_HU3GE_AUTO_SHUTDOWN_EN , Enable Power Domain 'PD_CP0_HU3GE' automatically Power-off when AP into Deep Sleep. 0 :  Power Domain SHUTDOWN by 'PD_CP0_HU3GE_FORCE_SHUTDOWN'; 1 : Power domain Automatically SHUTDOWN when AP enter Deep Sleep;" "Power Domain SHUTDOWN by 'PD_CP,Power domain Automatically SHUTDOWN when AP enter Deep Sleep;"
      BITFLD.LONG 0x00 16.--23. "  PD_CP0_HU3GE_PWR_ON_DLY , Delay time for  'PD_CP0_HU3GE'  from turn power switch to asserting power reset,  in power up process, with unit of 30us." "none"
      TEXTLINE "                                            "
      BITFLD.LONG 0x00 8.--15. "  PD_CP0_HU3GE_PWR_ON_SEQ_DLY , Delay time for  'PD_CP0_HU3GE'  from Powering up,  in power up process, with unit of 30us." "none"
      BITFLD.LONG 0x00 0.--7. "          PD_CP0_HU3GE_ISO_ON_DLY     , Delay time for  'PD_CP0_HU3GE'  from enable isolation cell to turn-off power switch, in power on process. with unit of 30us." "none"
  GROUP.LONG 0x0030++0x3 "0x402B0000 + 0x0030"
    LINE.LONG 0x00 "PD_CP0_GSM_0_CFG"
      BITFLD.LONG 0x00 26.--31. "  Reserved                    , " "Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved"
      BITFLD.LONG 0x00 25. "  PD_CP0_GSM_0_FORCE_SHUTDOWN , Force Power Domain 'PD_CP0_GSM' SHUTDOWN. Only effective when 'PD_CP0_GSM_AUTO_SHUTDOWN_EN' de-asserted." "0,1"
      BITFLD.LONG 0x00 24. "  PD_CP0_GSM_0_AUTO_SHUTDOWN_EN , Enable Power Domain 'PD_CP0_GSM' automatically Power-off when AP into Deep Sleep. 0 :  Power Domain SHUTDOWN by 'PD_CP0_GSM_FORCE_SHUTDOWN'; 1 : Power domain Automatically SHUTDOWN when AP enter Deep Sleep;" "Power Domain SHUTDOWN by 'PD_CP,Power domain Automatically SHUTDOWN when AP enter Deep Sleep;"
      BITFLD.LONG 0x00 16.--23. "  PD_CP0_GSM_0_PWR_ON_DLY , Delay time for  'PD_CP0_GSM'  from turn power switch to asserting power reset,  in power up process, with unit of 30us." "none"
      TEXTLINE "                                            "
      BITFLD.LONG 0x00 8.--15. "  PD_CP0_GSM_0_PWR_ON_SEQ_DLY , Delay time for  'PD_CP0_GSM'  from Powering up,  in power up process, with unit of 30us." "none"
      BITFLD.LONG 0x00 0.--7. "          PD_CP0_GSM_0_ISO_ON_DLY     , Delay time for  'PD_CP0_GSM'  from enable isolation cell to turn-off power switch, in power on process. with unit of 30us." "none"
  GROUP.LONG 0x0034++0x3 "0x402B0000 + 0x0034"
    LINE.LONG 0x00 "PD_CP0_GSM_1_CFG"
      BITFLD.LONG 0x00 26.--31. "  Reserved                    , " "Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved"
      BITFLD.LONG 0x00 25. "  PD_CP0_GSM_1_FORCE_SHUTDOWN , Force Power Domain 'PD_CP0_GSM' SHUTDOWN. Only effective when 'PD_CP0_GSM_AUTO_SHUTDOWN_EN' de-asserted." "0,1"
      BITFLD.LONG 0x00 24. "  PD_CP0_GSM_1_AUTO_SHUTDOWN_EN , Enable Power Domain 'PD_CP0_GSM' automatically Power-off when AP into Deep Sleep. 0 :  Power Domain SHUTDOWN by 'PD_CP0_GSM_FORCE_SHUTDOWN'; 1 : Power domain Automatically SHUTDOWN when AP enter Deep Sleep;" "Power Domain SHUTDOWN by 'PD_CP,Power domain Automatically SHUTDOWN when AP enter Deep Sleep;"
      BITFLD.LONG 0x00 16.--23. "  PD_CP0_GSM_1_PWR_ON_DLY , Delay time for  'PD_CP0_GSM'  from turn power switch to asserting power reset,  in power up process, with unit of 30us." "none"
      TEXTLINE "                                            "
      BITFLD.LONG 0x00 8.--15. "  PD_CP0_GSM_1_PWR_ON_SEQ_DLY , Delay time for  'PD_CP0_GSM'  from Powering up,  in power up process, with unit of 30us." "none"
      BITFLD.LONG 0x00 0.--7. "          PD_CP0_GSM_1_ISO_ON_DLY     , Delay time for  'PD_CP0_GSM'  from enable isolation cell to turn-off power switch, in power on process. with unit of 30us." "none"
  GROUP.LONG 0x0038++0x3 "0x402B0000 + 0x0038"
    LINE.LONG 0x00 "PD_CP0_TD_CFG"
      BITFLD.LONG 0x00 26.--31. "  Reserved                 , " "Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved"
      BITFLD.LONG 0x00 25. "  PD_CP0_TD_FORCE_SHUTDOWN , Force Power Domain 'PD_CP0_TD' SHUTDOWN. Only effective when 'PD_CP0_TD_AUTO_SHUTDOWN_EN' de-asserted." "0,1"
      BITFLD.LONG 0x00 24. "  PD_CP0_TD_AUTO_SHUTDOWN_EN , Enable Power Domain 'PD_CP0_TD' automatically Power-off when AP into Deep Sleep. 0 :  Power Domain SHUTDOWN by 'PD_CP0_TD_FORCE_SHUTDOWN'; 1 : Power domain Automatically SHUTDOWN when AP enter Deep Sleep;" "Power Domain SHUTDOWN by 'PD_CP,Power domain Automatically SHUTDOWN when AP enter Deep Sleep;"
      BITFLD.LONG 0x00 16.--23. "  PD_CP0_TD_PWR_ON_DLY , Delay time for  'PD_CP0_TD'  from turn power switch to asserting power reset,  in power up process, with unit of 30us." "none"
      TEXTLINE "                                            "
      BITFLD.LONG 0x00 8.--15. "  PD_CP0_TD_PWR_ON_SEQ_DLY , Delay time for  'PD_CP0_TD'  from Powering up,  in power up process, with unit of 30us." "none"
      BITFLD.LONG 0x00 0.--7. "          PD_CP0_TD_ISO_ON_DLY     , Delay time for  'PD_CP0_TD'  from enable isolation cell to turn-off power switch, in power on process. with unit of 30us." "none"
  GROUP.LONG 0x003C++0x3 "0x402B0000 + 0x003C"
    LINE.LONG 0x00 "PD_CP0_CEVA_0_CFG"
      BITFLD.LONG 0x00 26.--31. "  Reserved                     , " "Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved"
      BITFLD.LONG 0x00 25. "  PD_CP0_CEVA_0_FORCE_SHUTDOWN , Force Power Domain 'PD_CP0_CEVA' SHUTDOWN. Only effective when 'PD_CP0_CEVA_AUTO_SHUTDOWN_EN' de-asserted." "0,1"
      BITFLD.LONG 0x00 24. "  PD_CP0_CEVA_0_AUTO_SHUTDOWN_EN , Enable Power Domain 'PD_CP0_CEVA' automatically Power-off when AP into Deep Sleep. 0 :  Power Domain SHUTDOWN by 'PD_CP0_CEVA_FORCE_SHUTDOWN'; 1 : Power domain Automatically SHUTDOWN when AP enter Deep Sleep;" "Power Domain SHUTDOWN by 'PD_CP,Power domain Automatically SHUTDOWN when AP enter Deep Sleep;"
      BITFLD.LONG 0x00 16.--23. "  PD_CP0_CEVA_0_PWR_ON_DLY , Delay time for  'PD_CP0_CEVA'  from turn power switch to asserting power reset,  in power up process, with unit of 30us." "none"
      TEXTLINE "                                            "
      BITFLD.LONG 0x00 8.--15. "  PD_CP0_CEVA_0_PWR_ON_SEQ_DLY , Delay time for  'PD_CP0_CEVA'  from Powering up,  in power up process, with unit of 30us." "none"
      BITFLD.LONG 0x00 0.--7. "          PD_CP0_CEVA_0_ISO_ON_DLY     , Delay time for  'PD_CP0_CEVA'  from enable isolation cell to turn-off power switch, in power on process. with unit of 30us." "none"
  GROUP.LONG 0x0040++0x3 "0x402B0000 + 0x0040"
    LINE.LONG 0x00 "PD_CP0_CEVA_1_CFG"
      BITFLD.LONG 0x00 26.--31. "  Reserved                     , " "Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved"
      BITFLD.LONG 0x00 25. "  PD_CP0_CEVA_1_FORCE_SHUTDOWN , Force Power Domain 'PD_CP0_CEVA' SHUTDOWN. Only effective when 'PD_CP0_CEVA_AUTO_SHUTDOWN_EN' de-asserted." "0,1"
      BITFLD.LONG 0x00 24. "  PD_CP0_CEVA_1_AUTO_SHUTDOWN_EN , Enable Power Domain 'PD_CP0_CEVA' automatically Power-off when AP into Deep Sleep. 0 :  Power Domain SHUTDOWN by 'PD_CP0_CEVA_FORCE_SHUTDOWN'; 1 : Power domain Automatically SHUTDOWN when AP enter Deep Sleep;" "Power Domain SHUTDOWN by 'PD_CP,Power domain Automatically SHUTDOWN when AP enter Deep Sleep;"
      BITFLD.LONG 0x00 16.--23. "  PD_CP0_CEVA_1_PWR_ON_DLY , Delay time for  'PD_CP0_CEVA'  from turn power switch to asserting power reset,  in power up process, with unit of 30us." "none"
      TEXTLINE "                                            "
      BITFLD.LONG 0x00 8.--15. "  PD_CP0_CEVA_1_PWR_ON_SEQ_DLY , Delay time for  'PD_CP0_CEVA'  from Powering up,  in power up process, with unit of 30us." "none"
      BITFLD.LONG 0x00 0.--7. "          PD_CP0_CEVA_1_ISO_ON_DLY     , Delay time for  'PD_CP0_CEVA'  from enable isolation cell to turn-off power switch, in power on process. with unit of 30us." "none"
  GROUP.LONG 0x0044++0x3 "0x402B0000 + 0x0044"
    LINE.LONG 0x00 "PD_CP0_SYS_CFG"
  GROUP.LONG 0x0048++0x3 "0x402B0000 + 0x0048"
    LINE.LONG 0x00 "PD_CP1_CA5_CFG"
      BITFLD.LONG 0x00 26.--31. "  Reserved                  , " "Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved"
      BITFLD.LONG 0x00 25. "  PD_CP1_CA5_FORCE_SHUTDOWN , Force Power Domain 'PD_CP1_CA5' SHUTDOWN. Only effective when 'PD_CP1_CA5_AUTO_SHUTDOWN_EN' de-asserted." "0,1"
      BITFLD.LONG 0x00 24. "  PD_CP1_CA5_AUTO_SHUTDOWN_EN , Enable Power Domain 'PD_CP1_CA5' automatically Power-off when AP into Deep Sleep. 0 :  Power Domain SHUTDOWN by 'PD_CP1_CA5_FORCE_SHUTDOWN'; 1 : Power domain Automatically SHUTDOWN when AP enter Deep Sleep;" "Power Domain SHUTDOWN by 'PD_CP,Power domain Automatically SHUTDOWN when AP enter Deep Sleep;"
      BITFLD.LONG 0x00 16.--23. "  PD_CP1_CA5_PWR_ON_DLY , Delay time for  'PD_CP1_CA5'  from turn power switch to asserting power reset,  in power up process, with unit of 30us." "none"
      TEXTLINE "                                            "
      BITFLD.LONG 0x00 8.--15. "  PD_CP1_CA5_PWR_ON_SEQ_DLY , Delay time for  'PD_CP1_CA5'  from Powering up,  in power up process, with unit of 30us." "none"
      BITFLD.LONG 0x00 0.--7. "          PD_CP1_CA5_ISO_ON_DLY     , Delay time for  'PD_CP1_CA5'  from enable isolation cell to turn-off power switch, in power on process. with unit of 30us." "none"
  GROUP.LONG 0x004C++0x3 "0x402B0000 + 0x004C"
    LINE.LONG 0x00 "PD_CP1_LTE_P1_CFG"
      BITFLD.LONG 0x00 26.--31. "  Reserved                     , " "Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved"
      BITFLD.LONG 0x00 25. "  PD_CP1_LTE_P1_FORCE_SHUTDOWN , Force Power Domain 'PD_CP1_LTE_P1' SHUTDOWN. Only effective when 'PD_CP1_LTE_P1_AUTO_SHUTDOWN_EN' de-asserted." "0,1"
      BITFLD.LONG 0x00 24. "  PD_CP1_LTE_P1_AUTO_SHUTDOWN_EN , Enable Power Domain 'PD_CP1_LTE_P1' automatically Power-off when AP into Deep Sleep. 0 :  Power Domain SHUTDOWN by 'PD_CP1_LTE_P1_FORCE_SHUTDOWN'; 1 : Power domain Automatically SHUTDOWN when AP enter Deep Sleep;" "Power Domain SHUTDOWN by 'PD_CP,Power domain Automatically SHUTDOWN when AP enter Deep Sleep;"
      BITFLD.LONG 0x00 16.--23. "  PD_CP1_LTE_P1_PWR_ON_DLY , Delay time for  'PD_CP1_LTE_P1'  from turn power switch to asserting power reset,  in power up process, with unit of 30us." "none"
      TEXTLINE "                                            "
      BITFLD.LONG 0x00 8.--15. "  PD_CP1_LTE_P1_PWR_ON_SEQ_DLY , Delay time for  'PD_CP1_LTE_P1'  from Powering up,  in power up process, with unit of 30us." "none"
      BITFLD.LONG 0x00 0.--7. "          PD_CP1_LTE_P1_ISO_ON_DLY     , Delay time for  'PD_CP1_LTE_P1'  from enable isolation cell to turn-off power switch, in power on process. with unit of 30us." "none"
  GROUP.LONG 0x0050++0x3 "0x402B0000 + 0x0050"
    LINE.LONG 0x00 "PD_CP1_LTE_P2_CFG"
      BITFLD.LONG 0x00 26.--31. "  Reserved                     , " "Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved"
      BITFLD.LONG 0x00 25. "  PD_CP1_LTE_P2_FORCE_SHUTDOWN , Force Power Domain 'PD_CP1_LTE_P2' shutdown. Only effective when 'PD_CP1_LTE_P2_AUTO_SHUTDOWN_EN' de-asserted." "0,1"
      BITFLD.LONG 0x00 24. "  PD_CP1_LTE_P2_AUTO_SHUTDOWN_EN , Enable Power Domain 'PD_CP1_LTE_P2' automatically Power-off when AP into Deep Sleep. 0 :  Power Domain shutdown by 'PD_CP1_LTE_P2_FORCE_SHUTDOWN'; 1 : Power domain Automatically shutdown when AP enter Deep Sleep;" "Power Domain shutdown by 'PD_CP,Power domain Automatically shutdown when AP enter Deep Sleep;"
      BITFLD.LONG 0x00 16.--23. "  PD_CP1_LTE_P2_PWR_ON_DLY , Delay time for  'PD_CP1_LTE_P2'  from turn power switch to asserting power reset,  in power up process, with unit of 30us." "none"
      TEXTLINE "                                            "
      BITFLD.LONG 0x00 8.--15. "  PD_CP1_LTE_P2_PWR_ON_SEQ_DLY , Delay time for  'PD_CP1_LTE_P2'  from Powering up,  in power up process, with unit of 30us." "none"
      BITFLD.LONG 0x00 0.--7. "          PD_CP1_LTE_P2_ISO_ON_DLY     , Delay time for  'PD_CP1_LTE_P2'  from enable isolation cell to turn-off power switch, in power on process. with unit of 30us." "none"
  GROUP.LONG 0x0054++0x3 "0x402B0000 + 0x0054"
    LINE.LONG 0x00 "PD_CP1_CEVA_CFG"
      BITFLD.LONG 0x00 26.--31. "  Reserved                   , " "Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved"
      BITFLD.LONG 0x00 25. "  PD_CP1_CEVA_FORCE_SHUTDOWN , Force Power Domain 'PD_CP1_CEVA' SHUTDOWN. Only effective when 'PD_CP1_CEVA_AUTO_SHUTDOWN_EN' de-asserted." "0,1"
      BITFLD.LONG 0x00 24. "  PD_CP1_CEVA_AUTO_SHUTDOWN_EN , Enable Power Domain 'PD_CP1_CEVA' automatically Power-off when AP into Deep Sleep. 0 :  Power Domain SHUTDOWN by 'PD_CP1_CEVA_FORCE_SHUTDOWN'; 1 : Power domain Automatically SHUTDOWN when AP enter Deep Sleep;" "Power Domain SHUTDOWN by 'PD_CP,Power domain Automatically SHUTDOWN when AP enter Deep Sleep;"
      BITFLD.LONG 0x00 16.--23. "  PD_CP1_CEVA_PWR_ON_DLY , Delay time for  'PD_CP1_CEVA'  from turn power switch to asserting power reset,  in power up process, with unit of 30us." "none"
      TEXTLINE "                                            "
      BITFLD.LONG 0x00 8.--15. "  PD_CP1_CEVA_PWR_ON_SEQ_DLY , Delay time for  'PD_CP1_CEVA'  from Powering up,  in power up process, with unit of 30us." "none"
      BITFLD.LONG 0x00 0.--7. "          PD_CP1_CEVA_ISO_ON_DLY     , Delay time for  'PD_CP1_CEVA'  from enable isolation cell to turn-off power switch, in power on process. with unit of 30us." "none"
  GROUP.LONG 0x0058++0x3 "0x402B0000 + 0x0058"
    LINE.LONG 0x00 "PD_CP1_COMWRAP_CFG"
      BITFLD.LONG 0x00 26.--31. "  Reserved                      , " "Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved"
      BITFLD.LONG 0x00 25. "  PD_CP1_COMWRAP_FORCE_SHUTDOWN , Force Power Domain 'PD_CP1_COMWRAP' SHUTDOWN. Only effective when 'PD_CP1_COMWRAP_AUTO_SHUTDOWN_EN' de-asserted." "0,1"
      BITFLD.LONG 0x00 24. "  PD_CP1_COMWRAP_AUTO_SHUTDOWN_EN , " "0,1"
      BITFLD.LONG 0x00 16.--23. "  PD_CP1_COMWRAP_PWR_ON_DLY , Delay time for  'PD_CP1_COMWRAP'  from turn power switch to asserting power reset,  in power up process, with unit of 30us." "none"
      TEXTLINE "                                            "
      BITFLD.LONG 0x00 8.--15. "  PD_CP1_COMWRAP_PWR_ON_SEQ_DLY , Delay time for  'PD_CP1_COMWRAP'  from Powering up,  in power up process, with unit of 30us." "none"
      BITFLD.LONG 0x00 0.--7. "          PD_CP1_COMWRAP_ISO_ON_DLY     , Delay time for  'PD_CP1_COMWRAP'  from enable isolation cell to turn-off power switch, in power on process. with unit of 30us." "none"
  GROUP.LONG 0x005C++0x3 "0x402B0000 + 0x005C"
    LINE.LONG 0x00 "PD_PUB_SYS_CFG"
      BITFLD.LONG 0x00 26.--31. "  Reserved                  , " "Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved"
      BITFLD.LONG 0x00 25. "  PD_PUB_SYS_FORCE_SHUTDOWN , Force Power Domain 'PD_PUB_SYS' SHUTDOWN. Only effective when 'PD_PUB_SYS_AUTO_SHUTDOWN_EN' de-asserted." "0,1"
      BITFLD.LONG 0x00 24. "  PD_PUB_SYS_AUTO_SHUTDOWN_EN , Enable Power Domain 'PD_PUB_SYS' automatically Power-off when AP into Deep Sleep. 0 :  Power Domain SHUTDOWN by 'PD_PUB_SYS_FORCE_SHUTDOWN'; 1 : Power domain Automatically SHUTDOWN when AP enter Deep Sleep;" "Power Domain SHUTDOWN by 'PD_PUB_SYS_FORCE_SHUTDOWN';,Power domain Automatically SHUTDOWN when AP enter Deep Sleep;"
      BITFLD.LONG 0x00 16.--23. "  PD_PUB_SYS_PWR_ON_DLY , Delay time for  'PD_PUB_SYS'  from turn power switch to asserting power reset,  in power up process, with unit of 30us." "none"
      TEXTLINE "                                            "
      BITFLD.LONG 0x00 8.--15. "  PD_PUB_SYS_PWR_ON_SEQ_DLY , Delay time for  'PD_PUB_SYS'  from Powering up,  in power up process, with unit of 30us." "none"
      BITFLD.LONG 0x00 0.--7. "          PD_PUB_SYS_ISO_ON_DLY     , Delay time for  'PD_PUB_SYS'  from enable isolation cell to turn-off power switch, in power on process. with unit of 30us." "none"
  GROUP.LONG 0x0060++0x3 "0x402B0000 + 0x0060"
    LINE.LONG 0x00 "AP_WAKEUP_POR_CFG"
      BITFLD.LONG 0x00 0. "  AP_WAKEUP_POR_N , By default, to wakeup AP after chip power up. Software MUST set this bit to 1'b1 before enter AP light/deep sleep." "0,1"
  GROUP.LONG 0x0070++0x3 "0x402B0000 + 0x0070"
    LINE.LONG 0x00 "XTL_WAIT_CNT"
      BITFLD.LONG 0x00 8.--15. "  XTL1_WAIT_CNT , Wait time for XTL1 clock stable, with unit 30us. By default 4.98ms." "none"
      BITFLD.LONG 0x00 0.--7. "  XTL0_WAIT_CNT , Wait time for XTL0 clock stable, with unit 30us. By default 4.98ms." "none"
  GROUP.LONG 0x0074++0x3 "0x402B0000 + 0x0074"
    LINE.LONG 0x00 "XTLBUF_WAIT_CNT"
      BITFLD.LONG 0x00 8.--15. "  XTLBUF1_WAIT_CNT , Wait time for XTL1 BUF clock stable, with unit 30us. By default 0.96ms." "none"
      BITFLD.LONG 0x00 0.--7. "  XTLBUF0_WAIT_CNT , Wait time for XTL1 BUF clock stable, with unit 30us. By default 0.96ms." "none"
  GROUP.LONG 0x0078++0x3 "0x402B0000 + 0x0078"
    LINE.LONG 0x00 "PLL_WAIT_CNT1"
      BITFLD.LONG 0x00 24.--31. "  LTEPLL_WAIT_CNT , Wait time for LTEPLL clock stable, with unit 30us. By default 0.96ms." "none"
      BITFLD.LONG 0x00 16.--23. "  TWPLL_WAIT_CNT , Wait time for TWPLL clock stable, with unit 30us. By default 0.96ms." "none"
      BITFLD.LONG 0x00 8.--15. "  DPLL_WAIT_CNT , Wait time for DPLL clock stable, with unit 30us. By default 0.96ms." "none"
      BITFLD.LONG 0x00 0.--7. "  MPLL_WAIT_CNT , Wait time for MPLL clock stable, with unit 30us. By default 0.96ms." "none"
      TEXTLINE "                                            "
  GROUP.LONG 0x007C++0x3 "0x402B0000 + 0x007C"
    LINE.LONG 0x00 "PLL_WAIT_CNT2"
      BITFLD.LONG 0x00 0.--7. "  LVDSDIS_PLL_WAIT_CNT , Wait time for LVDSDIS_PLL clock stable, with unit 30us. By default 0.96ms." "none"
  GROUP.LONG 0x0080++0x3 "0x402B0000 + 0x0080"
    LINE.LONG 0x00 "XTL0_REL_CFG"
      BITFLD.LONG 0x00 5. "  XTL0_ARM7_SEL , XTL0 selected by ARM7 sys. Once selected, XTL0 would SHUTDOWN after ARM7 sys into deep sleep; 0 : XTL0 not selected by ARM7 sys; 1 : XTL0 selected by ARM7 Sys." "XTL,XTL"
      BITFLD.LONG 0x00 4. "  XTL0_VCP1_SEL , XTL0 selected by VCP1 sys. Once selected, XTL0 would SHUTDOWN after VCP1 sys into deep sleep; 0 : XTL0 not selected by VCP1 sys; 1 : XTL0 selected by VCP1 Sys." "XTL,XTL"
      BITFLD.LONG 0x00 3. "  XTL0_VCP0_SEL , XTL0 selected by VCP0 sys. Once selected, XTL0 would SHUTDOWN after VCP0 sys into deep sleep; 0 : XTL0 not selected by VCP0 sys; 1 : XTL0 selected by VCP0 Sys." "XTL,XTL"
      BITFLD.LONG 0x00 2. "  XTL0_CP1_SEL , XTL0 selected by CP1 sys. Once selected, XTL0 would SHUTDOWN after CP1 sys into deep sleep; 0 : XTL0 not selected by CP1 sys; 1 : XTL0 selected by CP1 Sys." "XTL,XTL"
      TEXTLINE "                                            "
      BITFLD.LONG 0x00 1. "  XTL0_CP0_SEL  , XTL0 selected by CP0 sys. Once selected, XTL0 would SHUTDOWN after CP0 sys into deep sleep; 0 : XTL0 not selected by CP0 sys; 1 : XTL0 selected by CP0 Sys." "XTL,XTL"
      BITFLD.LONG 0x00 0. "  XTL0_AP_SEL   , XTL0 selected by AP sys. Once selected, XTL0 would SHUTDOWN after AP sys into deep sleep; 0 : XTL0 not selected by AP sys; 1 : XTL0 selected by AP Sys." "XTL,XTL"
  GROUP.LONG 0x0084++0x3 "0x402B0000 + 0x0084"
    LINE.LONG 0x00 "XTL1_REL_CFG"
      BITFLD.LONG 0x00 5. "  XTL1_ARM7_SEL , XTL1 selected by ARM7 sys. Once selected, XTL1 would SHUTDOWN after ARM7 sys into deep sleep; 0 : XTL1 not selected by ARM7 sys; 1 : XTL1 selected by ARM7 Sys." "XTL,XTL"
      BITFLD.LONG 0x00 4. "  XTL1_VCP1_SEL , XTL1 selected by VCP1 sys. Once selected, XTL1 would SHUTDOWN after VCP1 sys into deep sleep; 0 : XTL1 not selected by VCP1 sys; 1 : XTL1 selected by VCP1 Sys." "XTL,XTL"
      BITFLD.LONG 0x00 3. "  XTL1_VCP0_SEL , XTL1 selected by VCP0 sys. Once selected, XTL1 would SHUTDOWN after VCP0 sys into deep sleep; 0 : XTL1 not selected by VCP0 sys; 1 : XTL1 selected by VCP0 Sys." "XTL,XTL"
      BITFLD.LONG 0x00 2. "  XTL1_CP1_SEL , XTL1 selected by CP1 sys. Once selected, XTL1 would SHUTDOWN after CP1 sys into deep sleep; 0 : XTL1 not selected by CP1 sys; 1 : XTL1 selected by CP1 Sys." "XTL,XTL"
      TEXTLINE "                                            "
      BITFLD.LONG 0x00 1. "  XTL1_CP0_SEL  , XTL1 selected by CP0 sys. Once selected, XTL1 would SHUTDOWN after CP0 sys into deep sleep; 0 : XTL1 not selected by CP0 sys; 1 : XTL1 selected by CP0 Sys." "XTL,XTL"
      BITFLD.LONG 0x00 0. "  XTL1_AP_SEL   , XTL1 selected by AP sys. Once selected, XTL1 would SHUTDOWN after AP sys into deep sleep; 0 : XTL1 not selected by AP sys; 1 : XTL1 selected by AP Sys." "XTL,XTL"
  GROUP.LONG 0x008C++0x3 "0x402B0000 + 0x008C"
    LINE.LONG 0x00 "XTLBUF0_REL_CFG"
      BITFLD.LONG 0x00 5. "  XTLBUF0_ARM7_SEL , XTLBUF0 selected by ARM7 sys. Once selected, XTLBUF0 would SHUTDOWN after ARM7 sys into deep sleep; 0 :XTLBUF0 not selected by ARM7 sys; 1 : XTLBUF0 selected by ARM7 Sys." "XTLBUF,XTLBUF"
      BITFLD.LONG 0x00 4. "  XTLBUF0_VCP1_SEL , XTLBUF0 selected by VCP1 sys. Once selected, XTLBUF0 would SHUTDOWN after VCP1 sys into deep sleep; 0 : XTLBUF0 not selected by VCP1 sys; 1 : XTLBUF0 selected by VCP1 Sys." "XTLBUF,XTLBUF"
      BITFLD.LONG 0x00 3. "  XTLBUF0_VCP0_SEL , XTLBUF0 selected by VCP0 sys. Once selected, XTLBUF0 would SHUTDOWN after VCP0 sys into deep sleep; 0 : XTLBUF0 not selected by VCP0 sys; 1 : XTLBUF0 selected by VCP0 Sys." "XTLBUF,XTLBUF"
      BITFLD.LONG 0x00 2. "  XTLBUF0_CP1_SEL , XTLBUF0 selected by CP1 sys. Once selected, XTLBUF0 would SHUTDOWN after CP1 sys into deep sleep; 0 : XTLBUF0 not selected by CP1 sys; 1 : XTLBUF0 selected by CP1 Sys." "XTLBUF,XTLBUF"
      TEXTLINE "                                            "
      BITFLD.LONG 0x00 1. "  XTLBUF0_CP0_SEL  , XTLBUF0 selected by CP0 sys. Once selected, XTLBUF0 would SHUTDOWN after CP0 sys into deep sleep; 0 : XTLBUF0 not selected by CP0 sys; 1 : XTLBUF0 selected by CP0 Sys." "XTLBUF,XTLBUF"
      BITFLD.LONG 0x00 0. "  XTLBUF0_AP_SEL   , XTLBUF0 selected by AP sys. Once selected, XTLBUF0 would SHUTDOWN after AP sys into deep sleep; 0 : XTLBUF0 not selected by AP sys; 1 : XTLBUF0 selected by AP Sys." "XTLBUF,XTLBUF"
  GROUP.LONG 0x0090++0x3 "0x402B0000 + 0x0090"
    LINE.LONG 0x00 "XTLBUF1_REL_CFG"
      BITFLD.LONG 0x00 5. "  XTLBUF1_ARM7_SEL , XTLBUF1 selected by ARM7 sys. Once selected, XTLBUF1 would SHUTDOWN after ARM7 sys into deep sleep; 0 :XTLBUF1 not selected by ARM7 sys; 1 : XTLBUF1 selected by ARM7 Sys." "XTLBUF,XTLBUF"
      BITFLD.LONG 0x00 4. "  XTLBUF1_VCP1_SEL , XTLBUF1 selected by VCP1 sys. Once selected, XTLBUF1 would SHUTDOWN after VCP1 sys into deep sleep; 0 : XTLBUF1 not selected by VCP1 sys; 1 : XTLBUF1 selected by VCP1 Sys." "XTLBUF,XTLBUF"
      BITFLD.LONG 0x00 3. "  XTLBUF1_VCP0_SEL , XTLBUF1 selected by VCP0 sys. Once selected, XTLBUF1 would SHUTDOWN after VCP0 sys into deep sleep; 0 : XTLBUF1 not selected by VCP0 sys; 1 : XTLBUF1 selected by VCP0 Sys." "XTLBUF,XTLBUF"
      BITFLD.LONG 0x00 2. "  XTLBUF1_CP1_SEL , XTLBUF1 selected by CP1 sys. Once selected, XTLBUF1 would SHUTDOWN after CP1 sys into deep sleep; 0 : XTLBUF1 not selected by CP1 sys; 1 : XTLBUF1 selected by CP1 Sys." "XTLBUF,XTLBUF"
      TEXTLINE "                                            "
      BITFLD.LONG 0x00 1. "  XTLBUF1_CP0_SEL  , XTLBUF1 selected by CP0 sys. Once selected, XTLBUF1 would SHUTDOWN after CP0 sys into deep sleep; 0 : XTLBUF1 not selected by CP0 sys; 1 : XTLBUF1 selected by CP0 Sys." "XTLBUF,XTLBUF"
      BITFLD.LONG 0x00 0. "  XTLBUF1_AP_SEL   , XTLBUF1 selected by AP sys. Once selected, XTLBUF1 would SHUTDOWN after AP sys into deep sleep; 0 : XTLBUF1 not selected by AP sys; 1 : XTLBUF1 selected by AP Sys." "XTLBUF,XTLBUF"
  GROUP.LONG 0x0094++0x3 "0x402B0000 + 0x0094"
    LINE.LONG 0x00 "MPLL_REL_CFG"
      BITFLD.LONG 0x00 8. "  MPLL_REF_SEL  , " "0,1"
      BITFLD.LONG 0x00 6.--7. "                         Reserved     , " "Reserved,Reserved,Reserved,Reserved"
      BITFLD.LONG 0x00 5. "                 MPLL_ARM7_SEL , MPLL selected by ARM7 sys. Once selected, MPLL would SHUTDOWN after ARM7 sys into deep sleep; 0 :MPLL not selected by ARM7 sys; 1 : MPLL selected by ARM7 Sys." "MPLL not selected by ARM,MPLL selected by ARM"
      BITFLD.LONG 0x00 4. "  MPLL_VCP1_SEL , MPLL selected by VCP1 sys. Once selected, MPLL would SHUTDOWN after VCP1 sys into deep sleep; 0 : MPLL not selected by VCP1 sys; 1 : MPLL selected by VCP1 Sys." "MPLL not selected by VCP,MPLL selected by VCP"
      TEXTLINE "                                            "
      BITFLD.LONG 0x00 3. "  MPLL_VCP0_SEL , MPLL selected by VCP0 sys. Once selected, MPLL would SHUTDOWN after VCP0 sys into deep sleep; 0 : MPLL not selected by VCP0 sys; 1 : MPLL selected by VCP0 Sys." "MPLL not selected by VCP,MPLL selected by VCP"
      BITFLD.LONG 0x00 2. "  MPLL_CP1_SEL , MPLL selected by CP1 sys. Once selected, MPLL would SHUTDOWN after CP1 sys into deep sleep; 0 : MPLL not selected by CP1 sys; 1 : MPLL selected by CP1 Sys." "MPLL not selected by CP,MPLL selected by CP"
      BITFLD.LONG 0x00 1. "  MPLL_CP0_SEL  , MPLL selected by CP0 sys. Once selected, MPLL would SHUTDOWN after CP0 sys into deep sleep; 0 : MPLL not selected by CP0 sys; 1 : MPLL selected by CP0 Sys." "MPLL not selected by CP,MPLL selected by CP"
      BITFLD.LONG 0x00 0. "   MPLL_AP_SEL   , MPLL selected by AP sys. Once selected, MPLL would SHUTDOWN after AP sys into deep sleep; 0 : MPLL not selected by AP sys; 1 : MPLL selected by AP Sys." "MPLL not selected by AP sys;,MPLL selected by AP Sys."
      TEXTLINE "                                            "
  GROUP.LONG 0x0098++0x3 "0x402B0000 + 0x0098"
    LINE.LONG 0x00 "DPLL_REL_CFG"
      BITFLD.LONG 0x00 8. "  DPLL_REF_SEL  , Not-used." "0,1"
      BITFLD.LONG 0x00 6.--7. "                         Reserved     , " "Reserved,Reserved,Reserved,Reserved"
      BITFLD.LONG 0x00 5. "                 DPLL_ARM7_SEL , DPLL selected by ARM7 sys. Once selected, MPLL would SHUTDOWN after ARM7 sys into deep sleep; 0 :MPLL not selected by ARM7 sys; 1 : MPLL selected by ARM7 Sys." "MPLL not selected by ARM,MPLL selected by ARM"
      BITFLD.LONG 0x00 4. "  DPLL_VCP1_SEL , DPLL selected by VCP1 sys. Once selected, DPLL would SHUTDOWN after VCP1 sys into deep sleep; 0 : DPLL not selected by VCP1 sys; 1 : DPLL selected by VCP1 Sys." "DPLL not selected by VCP,DPLL selected by VCP"
      TEXTLINE "                                            "
      BITFLD.LONG 0x00 3. "  DPLL_VCP0_SEL , DPLL selected by VCP0 sys. Once selected, DPLL would SHUTDOWN after VCP0 sys into deep sleep; 0 : DPLL not selected by VCP0 sys; 1 : DPLL selected by VCP0 Sys." "DPLL not selected by VCP,DPLL selected by VCP"
      BITFLD.LONG 0x00 2. "  DPLL_CP1_SEL , DPLL selected by CP1 sys. Once selected, DPLL would SHUTDOWN after CP1 sys into deep sleep; 0 : DPLL not selected by CP1 sys; 1 : DPLL selected by CP1 Sys." "DPLL not selected by CP,DPLL selected by CP"
      BITFLD.LONG 0x00 1. "  DPLL_CP0_SEL  , DPLL selected by CP0 sys. Once selected, DPLL would SHUTDOWN after CP0 sys into deep sleep; 0 : DPLL not selected by CP0 sys; 1 : DPLL selected by CP0 Sys." "DPLL not selected by CP,DPLL selected by CP"
      BITFLD.LONG 0x00 0. "   DPLL_AP_SEL   , DPLL selected by AP sys. Once selected, DPLL would SHUTDOWN after AP sys into deep sleep; 0 : DPLL not selected by AP sys; 1 : DPLL selected by AP Sys." "DPLL not selected by AP sys;,DPLL selected by AP Sys."
      TEXTLINE "                                            "
  GROUP.LONG 0x009C++0x3 "0x402B0000 + 0x009C"
    LINE.LONG 0x00 "LTEPLL_REL_CFG"
      BITFLD.LONG 0x00 8. "  LTEPLL_REF_SEL  , Not-used." "0,1"
      BITFLD.LONG 0x00 6.--7. "                           Reserved       , " "Reserved,Reserved,Reserved,Reserved"
      BITFLD.LONG 0x00 5. "                   LTEPLL_ARM7_SEL , LTEPLL selected by ARM7 sys. Once selected, LTEPLL would SHUTDOWN after ARM7 sys into deep sleep; 0 :LTEPLL not selected by ARM7 sys; 1 : LTEPLL selected by ARM7 Sys." "LTEPLL not selected by ARM,LTEPLL selected by ARM"
      BITFLD.LONG 0x00 4. "  LTEPLL_VCP1_SEL , LTEPLL selected by VCP1 sys. Once selected, LTEPLL would SHUTDOWN after VCP1 sys into deep sleep; 0 : LTEPLL not selected by VCP1 sys; 1 : LTEPLL selected by VCP1 Sys." "LTEPLL not selected by VCP,LTEPLL selected by VCP"
      TEXTLINE "                                            "
      BITFLD.LONG 0x00 3. "  LTEPLL_VCP0_SEL , LTEPLL selected by VCP0 sys. Once selected, LTEPLL would SHUTDOWN after VCP0 sys into deep sleep; 0 : LTEPLL not selected by VCP0 sys; 1 : LTEPLL selected by VCP0 Sys." "LTEPLL not selected by VCP,LTEPLL selected by VCP"
      BITFLD.LONG 0x00 2. "  LTEPLL_CP1_SEL , LTEPLL selected by CP1 sys. Once selected, LTEPLL would SHUTDOWN after CP1 sys into deep sleep; 0 : LTEPLL not selected by CP1 sys; 1 : LTEPLL selected by CP1 Sys." "LTEPLL not selected by CP,LTEPLL selected by CP"
      BITFLD.LONG 0x00 1. "  LTEPLL_CP0_SEL  , LTEPLL selected by CP0 sys. Once selected, LTEPLL would SHUTDOWN after CP0 sys into deep sleep; 0 : LTEPLL not selected by CP0 sys; 1 : LTEPLL selected by CP0 Sys." "LTEPLL not selected by CP,LTEPLL selected by CP"
      BITFLD.LONG 0x00 0. "   LTEPLL_AP_SEL   , LTEPLL selected by AP sys. Once selected, LTEPLL would SHUTDOWN after AP sys into deep sleep; 0 : LTEPLL not selected by AP sys; 1 : LTEPLL selected by AP Sys." "LTEPLL not selected by AP sys;,LTEPLL selected by AP Sys."
      TEXTLINE "                                            "
  GROUP.LONG 0x00A0++0x3 "0x402B0000 + 0x00A0"
    LINE.LONG 0x00 "TWPLL_REL_CFG"
      BITFLD.LONG 0x00 8. "  TWPLL_REF_SEL  , Not-used." "0,1"
      BITFLD.LONG 0x00 6.--7. "                          Reserved      , " "Reserved,Reserved,Reserved,Reserved"
      BITFLD.LONG 0x00 5. "                  TWPLL_ARM7_SEL , TWPLL selected by ARM7 sys. Once selected, TWPLL would SHUTDOWN after ARM7 sys into deep sleep; 0 :TWPLL not selected by ARM7 sys; 1 : TWPLL selected by ARM7 Sys." "TWPLL not selected by ARM,TWPLL selected by ARM"
      BITFLD.LONG 0x00 4. "  TWPLL_VCP1_SEL , TWPLL selected by VCP1 sys. Once selected, TWPLL would SHUTDOWN after VCP1 sys into deep sleep; 0 : TWPLL not selected by VCP1 sys; 1 : TWPLL selected by VCP1 Sys." "TWPLL not selected by VCP,TWPLL selected by VCP"
      TEXTLINE "                                            "
      BITFLD.LONG 0x00 3. "  TWPLL_VCP0_SEL , TWPLL selected by VCP0 sys. Once selected, TWPLL would SHUTDOWN after VCP0 sys into deep sleep; 0 : TWPLL not selected by VCP0 sys; 1 : TWPLL selected by VCP0 Sys." "TWPLL not selected by VCP,TWPLL selected by VCP"
      BITFLD.LONG 0x00 2. "  TWPLL_CP1_SEL , TWPLL selected by CP1 sys. Once selected, TWPLL would SHUTDOWN after CP1 sys into deep sleep; 0 : TWPLL not selected by CP1 sys; 1 : TWPLL selected by CP1 Sys." "TWPLL not selected by CP,TWPLL selected by CP"
      BITFLD.LONG 0x00 1. "  TWPLL_CP0_SEL  , TWPLL selected by CP0 sys. Once selected, TWPLL would SHUTDOWN after CP0 sys into deep sleep; 0 : TWPLL not selected by CP0 sys; 1 : TWPLL selected by CP0 Sys." "TWPLL not selected by CP,TWPLL selected by CP"
      BITFLD.LONG 0x00 0. "   TWPLL_AP_SEL   , TWPLL selected by AP sys. Once selected, TWPLL would SHUTDOWN after AP sys into deep sleep; 0 : TWPLL not selected by AP sys; 1 : TWPLL selected by AP Sys." "TWPLL not selected by AP sys;,TWPLL selected by AP Sys."
      TEXTLINE "                                            "
  GROUP.LONG 0x00A4++0x3 "0x402B0000 + 0x00A4"
    LINE.LONG 0x00 "LVDSDIS_PLL_REL_CFG"
      BITFLD.LONG 0x00 8. "  LVDSDIS_PLL_REF_SEL  , Not-used." "0,1"
      BITFLD.LONG 0x00 6.--7. "                                Reserved            , " "Reserved,Reserved,Reserved,Reserved"
      BITFLD.LONG 0x00 5. "                        LVDSDIS_PLL_ARM7_SEL , LVDSDIS_PLL selected by ARM7 sys. Once selected, LVDSDIS_PLL would SHUTDOWN after ARM7 sys into deep sleep; 0 :LVDSDIS_PLL not selected by ARM7 sys; 1 : LVDSDIS_PLL selected by ARM7 Sys." "LVDSDIS_PLL not selected by ARM,LVDSDIS_PLL selected by ARM"
      BITFLD.LONG 0x00 4. "  LVDSDIS_PLL_VCP1_SEL , LVDSDIS_PLL selected by VCP1 sys. Once selected, LVDSDIS_PLL would SHUTDOWN after VCP1 sys into deep sleep; 0 : LVDSDIS_PLL not selected by VCP1 sys; 1 : LVDSDIS_PLL selected by VCP1 Sys." "LVDSDIS_PLL not selected by VCP,LVDSDIS_PLL selected by VCP"
      TEXTLINE "                                            "
      BITFLD.LONG 0x00 3. "  LVDSDIS_PLL_VCP0_SEL , LVDSDIS_PLL selected by VCP0 sys. Once selected, LVDSDIS_PLL would SHUTDOWN after VCP0 sys into deep sleep; 0 : LVDSDIS_PLL not selected by VCP0 sys; 1 : LVDSDIS_PLL selected by VCP0 Sys." "LVDSDIS_PLL not selected by VCP,LVDSDIS_PLL selected by VCP"
      BITFLD.LONG 0x00 2. "  LVDSDIS_PLL_CP1_SEL , LVDSDIS_PLL selected by CP1 sys. Once selected, LVDSDIS_PLL would SHUTDOWN after CP1 sys into deep sleep; 0 : LVDSDIS_PLL not selected by CP1 sys; 1 : LVDSDIS_PLL selected by CP1 Sys." "LVDSDIS_PLL not selected by CP,LVDSDIS_PLL selected by CP"
      BITFLD.LONG 0x00 1. "  LVDSDIS_PLL_CP0_SEL  , LVDSDIS_PLL selected by CP0 sys. Once selected, LVDSDIS_PLL would SHUTDOWN after CP0 sys into deep sleep; 0 : LVDSDIS_PLL not selected by CP0 sys; 1 : LVDSDIS_PLL selected by CP0 Sys." "LVDSDIS_PLL not selected by CP,LVDSDIS_PLL selected by CP"
      BITFLD.LONG 0x00 0. "   LVDSDIS_PLL_AP_SEL   , LVDSDIS_PLL selected by AP sys. Once selected, LVDSDIS_PLL would SHUTDOWN after AP sys into deep sleep; 0 : LVDSDIS_PLL not selected by AP sys; 1 : LVDSDIS_PLL selected by AP Sys." "LVDSDIS_PLL not selected by AP sys;,LVDSDIS_PLL selected by AP Sys."
      TEXTLINE "                                            "
  GROUP.LONG 0x00B0++0x3 "0x402B0000 + 0x00B0"
    LINE.LONG 0x00 "CP_SOFT_RST"
      BITFLD.LONG 0x00 8. "  ARM7_SOFT_RST , ARM7 soft reset. 0 : Keep ARM7  in normal mode; 1 : Reset ARM7." "Keep ARM,Reset ARM"
      BITFLD.LONG 0x00 7. "                     Reserved    , " "Reserved,Reserved"
      BITFLD.LONG 0x00 6. "                     PUB_SOFT_RST , PUB Sys soft reset. 0 : Keep Pub Sys in normal mode; 1 : Reset Pub Sys." "Keep Pub Sys in normal mode;,Reset Pub Sys."
      BITFLD.LONG 0x00 5. "  AP_SOFT_RST  , AP Sys soft reset. 0 : Keep AP Sys in normal mode; 1 : Reset AP Sys." "Keep AP Sys in normal mode;,Reset AP Sys."
      TEXTLINE "                                            "
      BITFLD.LONG 0x00 4. "  GPU_SOFT_RST  , GPU Sys soft reset. 0 : Keep GPU Sys in normal mode; 1 : Reset GPU Sys." "Keep GPU Sys in normal mode;,Reset GPU Sys."
      BITFLD.LONG 0x00 3. "  MM_SOFT_RST , MM Sys soft reset. 0 : Keep MM Sys in normal mode; 1 : Reset MM Sys." "Keep MM Sys in normal mode;,Reset MM Sys."
      BITFLD.LONG 0x00 2. "  Reserved     , " "Reserved,Reserved"
      BITFLD.LONG 0x00 1. "                      CP1_SOFT_RST , CP1 Sys soft reset. 0 : Keep CP1 Sys in normal mode; 1 : Reset CP1 Sys." "Keep CP,Reset CP"
      TEXTLINE "                                            "
      BITFLD.LONG 0x00 0. "  CP0_SOFT_RST  , CP0 Sys soft reset. 0 : Keep CP0 Sys in normal mode; 1 : Reset CP0 Sys." "Keep CP,Reset CP"
  GROUP.LONG 0x00B4++0x3 "0x402B0000 + 0x00B4"
    LINE.LONG 0x00 "CP_SLP_STATUS_DBG0"
      BITFLD.LONG 0x00 16.--31. "  CP1_DEEP_SLP_DBG , Status of CP1 sys sleep, for Debug purpose." "none"
      BITFLD.LONG 0x00 0.--15. "  CP0_DEEP_SLP_DBG , Status of CP0 sys sleep, for Debug purpose." "none"
  GROUP.LONG 0x00BC++0x3 "0x402B0000 + 0x00BC"
    LINE.LONG 0x00 "PWR_STATUS0_DBG"
      BITFLD.LONG 0x00 28.--31. "  PD_MM_TOP_STATE , Status of power domain 'PD_MM_TOP', for debug purpose." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
      BITFLD.LONG 0x00 24.--27. "  PD_GPU_TOP_STATE , Status of power domain 'PD_GPU_TOP', for debug purpose." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
      BITFLD.LONG 0x00 20.--23. "  PD_AP_SYS_STATE , " "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
      BITFLD.LONG 0x00 16.--19. "  PD_CA7_C3_STATE  , Status of power domain 'PD_CA7_C3', for debug purpose." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
      TEXTLINE "                                            "
      BITFLD.LONG 0x00 12.--15. "  PD_CA7_C2_STATE , Status of power domain 'PD_CA7_C2', for debug purpose." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
      BITFLD.LONG 0x00 8.--11. "  PD_CA7_C1_STATE  , Status of power domain 'PD_CA7_C1', for debug purpose." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
      BITFLD.LONG 0x00 4.--7. "  PD_CA7_C0_STATE , Status of power domain 'PD_CA7_C0', for debug purpose." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
      BITFLD.LONG 0x00 0.--3. "  PD_CA7_TOP_STATE , Status of power domain 'PD_CA7_TOP', for debug purpose." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
      TEXTLINE "                                            "
  GROUP.LONG 0x00C0++0x3 "0x402B0000 + 0x00C0"
    LINE.LONG 0x00 "PWR_STATUS1_DBG"
      BITFLD.LONG 0x00 28.--31. "  PD_CP0_CEVA_1_STATE , Status of power domain 'PD_CP0_SYS', for debug purpose." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
      BITFLD.LONG 0x00 24.--27. "  PD_CP0_CEVA_0_STATE , " "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
      BITFLD.LONG 0x00 20.--23. "  PD_CP0_GSM_0_STATE  , Status of power domain 'PD_CP0_GSM', for debug purpose." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
      BITFLD.LONG 0x00 16.--19. "  PD_CP0_GSM_1_STATE , Status of power domain 'PD_CP0_HU3GE', for debug purpose." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
      TEXTLINE "                                            "
      BITFLD.LONG 0x00 12.--15. "  PD_CP0_HU3GE_STATE  , Status of power domain 'PD_CP0_ARM9_2, for debug purpose." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
      BITFLD.LONG 0x00 8.--11. "  PD_CP0_ARM9_1_STATE , Status of power domain 'PD_CP0_ARM9_1', for debug purpose." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
      BITFLD.LONG 0x00 4.--7. "  PD_CP0_ARM9_0_STATE , Status of power domain 'PD_CP0_ARM9_0', for debug purpose." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
      BITFLD.LONG 0x00 0.--3. "  PD_CP0_TD_STATE    , Status of power domain 'PD_AP_SYS', for debug purpose." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
      TEXTLINE "                                            "
  GROUP.LONG 0x00C4++0x3 "0x402B0000 + 0x00C4"
    LINE.LONG 0x00 "PWR_STATUS2_DBG"
      BITFLD.LONG 0x00 28.--31. "  Reserved            , " "Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved"
      BITFLD.LONG 0x00 24.--27. "  PD_PUB_SYS_STATE  , " "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
      BITFLD.LONG 0x00 20.--23. "  PD_CP1_COMWRAP_STATE , Status of power domain 'PD_CP1_COMWRAP', for debug purpose." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
      BITFLD.LONG 0x00 16.--19. "  PD_CP1_LTE_P2_STATE , Status of power domain 'PD_CP1_LTE_P2', for debug purpose." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
      TEXTLINE "                                            "
      BITFLD.LONG 0x00 12.--15. "  PD_CP1_LTE_P1_STATE , Status of power domain 'PD_CP1_LTE_P1', for debug purpose." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
      BITFLD.LONG 0x00 8.--11. "        PD_CP1_CEVA_STATE , Status of power domain 'PD_CP1_TW', for debug purpose." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
      BITFLD.LONG 0x00 4.--7. "  PD_CP1_CA5_STATE     , Status of power domain 'PD_CP1_GSM', for debug purpose." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
      BITFLD.LONG 0x00 0.--3. "  Reserved            , " "Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved"
      TEXTLINE "                                            "
  GROUP.LONG 0x00CC++0x3 "0x402B0000 + 0x00CC"
    LINE.LONG 0x00 "SLEEP_CTRL"
      BITFLD.LONG 0x00 29.--31. "  Reserved              , " "Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved"
      BITFLD.LONG 0x00 28. "   VCP1_FORCE_LIGHT_SLEEP , Force VCP1 light  sleep; 0 : not force 1 : force;" "not force,force;"
      BITFLD.LONG 0x00 27. "  VCP0_FORCE_LIGHT_SLEEP , Force VCP0 light sleep; 0 : not force 1 : force;" "not force,force;"
      BITFLD.LONG 0x00 26. "  CP1_FORCE_LIGHT_SLEEP , Force CP1 light  sleep; 0 : not force 1 : force;" "not force,force;"
      TEXTLINE "                                            "
      BITFLD.LONG 0x00 25. "  CP0_FORCE_LIGHT_SLEEP , Force CP0 light sleep; 0 : not force 1 : force;" "not force,force;"
      BITFLD.LONG 0x00 24. "  AP_FORCE_LIGHT_SLEEP   , Force AP light sleep; 0 : not force 1 : force;" "not force,force;"
      BITFLD.LONG 0x00 22.--23. "  Reserved               , " "Reserved,Reserved,Reserved,Reserved"
      BITFLD.LONG 0x00 21. "   ARM7_FORCE_DEEP_SLEEP , Force ARM7 deep sleep; 0 : not force 1 : force;" "not force,force;"
      TEXTLINE "                                            "
      BITFLD.LONG 0x00 20. "  VCP1_FORCE_DEEP_SLEEP , Force VCP1 deep sleep; 0 : not force 1 : force;" "not force,force;"
      BITFLD.LONG 0x00 19. "  VCP0_FORCE_DEEP_SLEEP  , Force VCP0 deep sleep; 0 : not force 1 : force;" "not force,force;"
      BITFLD.LONG 0x00 18. "  CP1_FORCE_DEEP_SLEEP   , Force CP1 deep sleep; 0 : not force 1 : force;" "not force,force;"
      BITFLD.LONG 0x00 17. "  CP0_FORCE_DEEP_SLEEP  , Force CP0 deep sleep; 0 : not force 1 : force;" "not force,force;"
      TEXTLINE "                                            "
      BITFLD.LONG 0x00 16. "  AP_FORCE_DEEP_SLEEP   , Force AP deep sleep; 0 : not force 1 : force;" "not force,force;"
      BITFLD.LONG 0x00 13.--15. "  Reserved               , " "Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved"
      BITFLD.LONG 0x00 12. "   VCP1_LIGHT_SLEEP       , VCp1 light sleep status." "0,1"
      BITFLD.LONG 0x00 11. "          VCP0_LIGHT_SLEEP      , VCp0 light sleep status." "0,1"
      TEXTLINE "                                            "
      BITFLD.LONG 0x00 10. "  CP1_LIGHT_SLEEP       , Cp1 light sleep status." "0,1"
      BITFLD.LONG 0x00 9. "          CP0_LIGHT_SLEEP        , Cp0 light sleep status." "0,1"
      BITFLD.LONG 0x00 8. "          AP_LIGHT_SLEEP         , AP light sleep status." "0,1"
      BITFLD.LONG 0x00 5.--7. "          Reserved              , " "Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved"
      TEXTLINE "                                            "
      BITFLD.LONG 0x00 4. "  VCP1_DEEP_SLEEP       , VCp1 deep sleep status." "0,1"
      BITFLD.LONG 0x00 3. "          VCP0_DEEP_SLEEP        , VCp0 deep sleep status." "0,1"
      BITFLD.LONG 0x00 2. "          CP1_DEEP_SLEEP         , Cp1 deep sleep status." "0,1"
      BITFLD.LONG 0x00 1. "          CP0_DEEP_SLEEP        , Cp0 deep sleep status." "0,1"
      TEXTLINE "                                            "
      BITFLD.LONG 0x00 0. "  AP_DEEP_SLEEP         , AP deep sleep status." "0,1"
  GROUP.LONG 0x00D0++0x3 "0x402B0000 + 0x00D0"
    LINE.LONG 0x00 "DDR_SLEEP_CTRL"
      BITFLD.LONG 0x00 16. "  BUSY_TRANSFER_HWDATA_SEL , " "0,1"
      BITFLD.LONG 0x00 13.--15. "                                                                                                                                                                                                                                                              Reserved              , " "Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved"
      BITFLD.LONG 0x00 12. "                                                                                                                                                                                                                                                                   DDR_PUBL_APB_SOFT_RST  , DDR PUBL APB Soft Reset. Active High; 0 : Keep DDR PUBL APB  in normal mode; 1 : Reset DDR PUBL APB;" "Keep DDR PUBL APB  in normal mode;,Reset DDR PUBL APB;"
      BITFLD.LONG 0x00 11. "                                                                                                                                   DDR_UMCTL_APB_SOFT_RST , DDR UMCTL APB Soft Reset. Active High; 0 : Keep DDR UMCTL APB  in normal mode; 1 : Reset DDR UMCTL APB;" "Keep DDR UMCTL APB  in normal mode;,Reset DDR UMCTL APB;"
      TEXTLINE "                                            "
      BITFLD.LONG 0x00 10. "  DDR_PUBL_SOFT_RST        , DDR PUBL Soft Reset. Active High; 0 : Keep DDR PUBL  in normal mode; 1 : Reset DDR PUBL;" "Keep DDR PUBL  in normal mode;,Reset DDR PUBL;"
      BITFLD.LONG 0x00 9. "                                                                                                                                                                                                                                 Reserved              , " "Reserved,Reserved"
      BITFLD.LONG 0x00 8. "                                                                                                                                                                                                                                                                   DDR_PHY_SOFT_RST       , DDR PHY Soft Reset. Active High; 0 : Keep DDR PHY in normal mode; 1 : Reset DDR PHY;" "Keep DDR PHY in normal mode;,Reset DDR PHY;"
      BITFLD.LONG 0x00 7. "                                                                                                                                         Reserved               , " "Reserved,Reserved"
      TEXTLINE "                                            "
      BITFLD.LONG 0x00 6. "  DDR_PHY_AUTO_GATE_EN     , DDR PHY Automatical disable. 0 : DDR PHY clock depends only on 'DDR_PHY_EB'; 1 : Not effecive if 'DDR_PHY_EB' assered. If 'DDR_PHY_EB' de-asserTW. DDR PHY clock would be automaticall on or off, according to the methods of DDR light sleep." "DDR PHY clock depends only on 'DDR_PHY_EB';,Not effecive if 'DDR_PHY_EB' assered. If 'DDR_PHY_EB' de-asserTW. DDR PHY clock would be automaticall on or off- according to the methods of DDR light sleep."
      BITFLD.LONG 0x00 5. "                                                                                                  DDR_PUBL_AUTO_GATE_EN , DDR PUBL Automatical disable. 0 : DDR PUBL clock depends only on 'DDR_PUBL_EB'; 1 : Not effecive if 'DDR_PUBL_EB' assered. If 'DDR_PUBL_EB' de-asserTW. DDR PUBL clock would be automaticall on or off, according to the methods of DDR light sleep." "DDR PUBL clock depends only on 'DDR_PUBL_EB';,Not effecive if 'DDR_PUBL_EB' assered. If 'DDR_PUBL_EB' de-asserTW. DDR PUBL clock would be automaticall on or off- according to the methods of DDR light sleep."
      BITFLD.LONG 0x00 4. "                                                                                                           DDR_UMCTL_AUTO_GATE_EN , DDR UMCTL Automatical disable. 0 : DDR UMCTL clock depends only on 'DDR_UMCTL_EB'; 1 : Not effecive if 'DDR_UMCTL_EB' assered. If 'DDR_UMCTL_EB' de-asserTW. DDR UMCTL clock would be automaticall on or off, according to the methods of DDR light sleep." "DDR UMCTL clock depends only on 'DDR_UMCTL_EB';,Not effecive if 'DDR_UMCTL_EB' assered. If 'DDR_UMCTL_EB' de-asserTW. DDR UMCTL clock would be automaticall on or off- according to the methods of DDR light sleep."
      BITFLD.LONG 0x00 3. "  Reserved               , " "Reserved,Reserved"
      TEXTLINE "                                            "
      BITFLD.LONG 0x00 2. "  DDR_PHY_EB               , DDR PHY Clock Enable. 0 : DDR PHY Clock depends on 'DDR_PHY_AUTO_GATE_EN', if 'DDR_PHY_AUTO_GATE_EN' asserted, DDR PHY clock would be automaticall on or off, according to the methods of DDR light sleep. If 'DDR_PHY_AUTO_GATE_EN' de-asserted, DDR PHY clock would be force disable. 1 : DDR PHY Clock Force enable." "DDR PHY Clock depends on 'DDR_PHY_AUTO_GATE_EN'- if 'DDR_PHY_AUTO_GATE_EN' asserted- DDR PHY clock would be automaticall on or off- according to the methods of DDR light sleep. If 'DDR_PHY_AUTO_GATE_EN' de-asserted- DDR PHY clock would be force disable.,DDR PHY Clock Force enable."
      BITFLD.LONG 0x00 1. "  DDR_UMCTL_EB          , DDR UMCTL Clock Enable. 0 : DDR UMCTL Clock depends on 'DDR_UMCTL_AUTO_GATE_EN', if 'DDR_UMCTL_AUTO_GATE_EN' asserted, DDR UMCTL clock would be automaticall on or off, according to the methods of DDR light sleep. If 'DDR_UMCTL_AUTO_GATE_EN' de-asserted, DDR UMCTL clock would be force disable. 1 : DDR UMCTL Clock Force enable." "DDR UMCTL Clock depends on 'DDR_UMCTL_AUTO_GATE_EN'- if 'DDR_UMCTL_AUTO_GATE_EN' asserted- DDR UMCTL clock would be automaticall on or off- according to the methods of DDR light sleep. If 'DDR_UMCTL_AUTO_GATE_EN' de-asserted- DDR UMCTL clock would be force disable.,DDR UMCTL Clock Force enable."
      BITFLD.LONG 0x00 0. "  DDR_PUBL_EB            , DDR PUBL Clock Enable. 0 : DDR PUBL Clock depends on 'DDR_PUBL_AUTO_GATE_EN', if 'DDR_PUBL_AUTO_GATE_EN' asserted, DDR PUBL clock would be automaticall on or off, according to the methods of DDR light sleep. If 'DDR_PUBL_AUTO_GATE_EN' de-asserted, DDR PUBL clock would be force disable. 1 : DDR PUBL Clock Force enable." "DDR PUBL Clock depends on 'DDR_PUBL_AUTO_GATE_EN'- if 'DDR_PUBL_AUTO_GATE_EN' asserted- DDR PUBL clock would be automaticall on or off- according to the methods of DDR light sleep. If 'DDR_PUBL_AUTO_GATE_EN' de-asserted- DDR PUBL clock would be force disable.,DDR PUBL Clock Force enable."
  GROUP.LONG 0x00D4++0x3 "0x402B0000 + 0x00D4"
    LINE.LONG 0x00 "SLEEP_STATUS"
      BITFLD.LONG 0x00 20.--23. "  ARM7_SLP_STATUS , FSM Status of ARM7 Sleep. For Debug Purpose." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
      BITFLD.LONG 0x00 16.--19. "  VCP1_SLP_STATUS , FSM Status of VCP1 Sleep. For Debug Purpose." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
      BITFLD.LONG 0x00 12.--15. "  VCP0_SLP_STATUS , FSM Status of VCP0 Sleep. For Debug Purpose." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
      BITFLD.LONG 0x00 8.--11. "  CP1_SLP_STATUS , FSM Status of CP1 Sleep. For Debug Purpose." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
      TEXTLINE "                                            "
      BITFLD.LONG 0x00 4.--7. "  CP0_SLP_STATUS  , FSM Status of CP0 Sleep. For Debug Purpose." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
      BITFLD.LONG 0x00 0.--3. "  AP_SLP_STATUS   , FSM Status of AP Sleep. For Debug Purpose." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  GROUP.LONG 0x00E4++0x3 "0x402B0000 + 0x00E4"
    LINE.LONG 0x00 "CA7_TOP_CFG"
      BITFLD.LONG 0x00 0. "  CA7_L2RSTDISABLE , Cortex-A7 'L2RSTDISABLE' control bit. Disable automatic L2 cache invalidate at reset. 0 : L2 cache is reset by hardware. 1 : L2 cache is not reset by hardware." "L,L"
  GROUP.LONG 0x00E8++0x3 "0x402B0000 + 0x00E8"
    LINE.LONG 0x00 "CA7_C0_CFG"
      BITFLD.LONG 0x00 0. "  CA7_VINITHI_C0 , Cortex-A7 Core0 'VINITHI' control bit.  Location of the exception vectors at reset. It sets the initial value of the V bit in the CP15 System Control Register (SCTLR): 0 : Exception vectors start at address 0x00000000. 1 : Exception vectors start at address 0xFFFF0000. This pin is only sampled during reset of the processor." "Exception vectors start at address,Exception vectors start at address"
  GROUP.LONG 0x00EC++0x3 "0x402B0000 + 0x00EC"
    LINE.LONG 0x00 "CA7_C1_CFG"
      BITFLD.LONG 0x00 0. "  CA7_VINITHI_C1 , Cortex-A7 Core1 'VINITHI' control bit.  Location of the exception vectors at reset. It sets the initial value of the V bit in the CP15 System Control Register (SCTLR): 0 : Exception vectors start at address 0x00000000. 1 : Exception vectors start at address 0xFFFF0000. This pin is only sampled during reset of the processor." "Exception vectors start at address,Exception vectors start at address"
  GROUP.LONG 0x00F0++0x3 "0x402B0000 + 0x00F0"
    LINE.LONG 0x00 "CA7_C2_CFG"
      BITFLD.LONG 0x00 0. "  CA7_VINITHI_C2 , Cortex-A7 Core2 'VINITHI' control bit.  Location of the exception vectors at reset. It sets the initial value of the V bit in the CP15 System Control Register (SCTLR): 0 : Exception vectors start at address 0x00000000. 1 : Exception vectors start at address 0xFFFF0000. This pin is only sampled during reset of the processor." "Exception vectors start at address,Exception vectors start at address"
  GROUP.LONG 0x00F4++0x3 "0x402B0000 + 0x00F4"
    LINE.LONG 0x00 "CA7_C3_CFG"
      BITFLD.LONG 0x00 0. "  CA7_VINITHI_C3 , Cortex-A7 Core3 'VINITHI' control bit.  Location of the exception vectors at reset. It sets the initial value of the V bit in the CP15 System Control Register (SCTLR): 0 : Exception vectors start at address 0x00000000. 1 : Exception vectors start at address 0xFFFF0000. This pin is only sampled during reset of the processor." "Exception vectors start at address,Exception vectors start at address"
  GROUP.LONG 0x00F8++0x3 "0x402B0000 + 0x00F8"
    LINE.LONG 0x00 "DDR_CHN_SLEEP_CTRL0"
      BITFLD.LONG 0x00 31. "  DDR_CTRL_AXI_LP_EN , " "0,1"
      BITFLD.LONG 0x00 30. "                                          DDR_CTRL_CGM_SEL   , " "0,1"
      BITFLD.LONG 0x00 26.--29. "                                          Reserved           , " "Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved"
      BITFLD.LONG 0x00 25. "                                   DDR_CHN9_AXI_LP_EN , DDR Channel 9 AXI port low power mode. 0 : Disable Low power mode, clock for channel 9 would be always available as long as Chip wakeup. 1 : Enable low power mode, clock for channel 9 would be stopped depending on 'DDR_CHN9_AXI_STOP_SEL' and 'DDR_CHN9_CGM_SEL' condition." "Disable Low power mode- clock for channel,Enable low power mode- clock for channel"
      TEXTLINE "                                            "
      BITFLD.LONG 0x00 24. "  DDR_CHN8_AXI_LP_EN , DDR Channel 8 AXI port low power mode. 0 : Disable Low power mode, clock for channel 8 would be always available as long as Chip wakeup. 1 : Enable low power mode, clock for channel 8 would be stopped depending on 'DDR_CHN8_AXI_STOP_SEL' and 'DDR_CHN8_CGM_SEL' condition." "Disable Low power mode- clock for channel,Enable low power mode- clock for channel"
      BITFLD.LONG 0x00 23. "  DDR_CHN7_AXI_LP_EN , DDR Channel 7 AXI port low power mode. 0 : Disable Low power mode, clock for channel 7 would be always available as long as Chip wakeup. 1 : Enable low power mode, clock for channel 7 would be stopped depending on 'DDR_CHN7_AXI_STOP_SEL' and 'DDR_CHN7_CGM_SEL' condition." "Disable Low power mode- clock for channel,Enable low power mode- clock for channel"
      BITFLD.LONG 0x00 22. "  DDR_CHN6_AXI_LP_EN , DDR Channel 6 AXI port low power mode. 0 : Disable Low power mode, clock for channel 6 would be always available as long as Chip wakeup. 1 : Enable low power mode, clock for channel 6 would be stopped depending on 'DDR_CHN6_AXI_STOP_SEL' and 'DDR_CHN6_CGM_SEL' condition." "Disable Low power mode- clock for channel,Enable low power mode- clock for channel"
      BITFLD.LONG 0x00 21. "  DDR_CHN5_AXI_LP_EN , DDR Channel 5 AXI port low power mode. 0 : Disable Low power mode, clock for channel 5 would be always available as long as Chip wakeup. 1 : Enable low power mode, clock for channel 5 would be stopped depending on 'DDR_CHN5_AXI_STOP_SEL' and 'DDR_CHN5_CGM_SEL' condition." "Disable Low power mode- clock for channel,Enable low power mode- clock for channel"
      TEXTLINE "                                            "
      BITFLD.LONG 0x00 20. "  DDR_CHN4_AXI_LP_EN , DDR Channel 4 AXI port low power mode. 0 : Disable Low power mode, clock for channel 4 would be always available as long as Chip wakeup. 1 : Enable low power mode, clock for channel 4 would be stopped depending on 'DDR_CHN4_AXI_STOP_SEL' and 'DDR_CHN4_CGM_SEL' condition." "Disable Low power mode- clock for channel,Enable low power mode- clock for channel"
      BITFLD.LONG 0x00 19. "  DDR_CHN3_AXI_LP_EN , DDR Channel 3 AXI port low power mode. 0 : Disable Low power mode, clock for channel 3 would be always available as long as Chip wakeup. 1 : Enable low power mode, clock for channel 3 would be stopped depending on 'DDR_CHN3_AXI_STOP_SEL' and 'DDR_CHN3_CGM_SEL' condition." "Disable Low power mode- clock for channel,Enable low power mode- clock for channel"
      BITFLD.LONG 0x00 18. "  DDR_CHN2_AXI_LP_EN , DDR Channel 2 AXI port low power mode. 0 : Disable Low power mode, clock for channel 2 would be always available as long as Chip wakeup. 1 : Enable low power mode, clock for channel 2 would be stopped depending on 'DDR_CHN2_AXI_STOP_SEL' and 'DDR_CHN2_CGM_SEL' condition." "Disable Low power mode- clock for channel,Enable low power mode- clock for channel"
      BITFLD.LONG 0x00 17. "  DDR_CHN1_AXI_LP_EN , DDR Channel 1 AXI port low power mode. 0 : Disable Low power mode, clock for channel 1 would be always available as long as Chip wakeup. 1 : Enable low power mode, clock for channel 1 would be stopped depending on 'DDR_CHN1_AXI_STOP_SEL' and 'DDR_CHN1_CGM_SEL' condition." "Disable Low power mode- clock for channel,Enable low power mode- clock for channel"
      TEXTLINE "                                            "
      BITFLD.LONG 0x00 16. "  DDR_CHN0_AXI_LP_EN , DDR Channel 0 AXI port low power mode. 0 : Disable Low power mode, clock for channel 0 would be always available as long as Chip wakeup. 1 : Enable low power mode, clock for channel 0 would be stopped depending on 'DDR_CHN0_AXI_STOP_SEL' and 'DDR_CHN0_CGM_SEL' condition." "Disable Low power mode- clock for channel,Enable low power mode- clock for channel"
      BITFLD.LONG 0x00 10.--15. "  Reserved           , " "Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved"
      BITFLD.LONG 0x00 9. "                                   DDR_CHN9_CGM_SEL   , DDR Channel 9 Clock Gating Control: 0 : AXI Low Power FSM control(Recommanded); 1 : AXI Low Power Interface of DDR Channel 9 'cactive_chn9';" "AXI Low Power FSM control(Recommanded);,AXI Low Power Interface of DDR Channel"
      BITFLD.LONG 0x00 8. "    DDR_CHN8_CGM_SEL   , DDR Channel 8 Clock Gating Control: 0 : AXI Low Power FSM control(Recommanded); 1 : AXI Low Power Interface of DDR Channel 8 'cactive_chn8';" "AXI Low Power FSM control(Recommanded);,AXI Low Power Interface of DDR Channel"
      TEXTLINE "                                            "
      BITFLD.LONG 0x00 7. "  DDR_CHN7_CGM_SEL   , DDR Channel 7 Clock Gating Control: 0 : AXI Low Power FSM control(Recommanded); 1 : AXI Low Power Interface of DDR Channel 7 'cactive_chn7';" "AXI Low Power FSM control(Recommanded);,AXI Low Power Interface of DDR Channel"
      BITFLD.LONG 0x00 6. "    DDR_CHN6_CGM_SEL   , DDR Channel 6 Clock Gating Control: 0 : AXI Low Power FSM control(Recommanded); 1 : AXI Low Power Interface of DDR Channel 6 'cactive_chn6';" "AXI Low Power FSM control(Recommanded);,AXI Low Power Interface of DDR Channel"
      BITFLD.LONG 0x00 5. "    DDR_CHN5_CGM_SEL   , DDR Channel 5 Clock Gating Control: 0 : AXI Low Power FSM control(Recommanded); 1 : AXI Low Power Interface of DDR Channel 5 'cactive_chn5';" "AXI Low Power FSM control(Recommanded);,AXI Low Power Interface of DDR Channel"
      BITFLD.LONG 0x00 4. "    DDR_CHN4_CGM_SEL   , DDR Channel 4 Clock Gating Control: 0 : AXI Low Power FSM control(Recommanded); 1 : AXI Low Power Interface of DDR Channel 4 'cactive_chn4';" "AXI Low Power FSM control(Recommanded);,AXI Low Power Interface of DDR Channel"
      TEXTLINE "                                            "
      BITFLD.LONG 0x00 3. "  DDR_CHN3_CGM_SEL   , DDR Channel 3 Clock Gating Control: 0 : AXI Low Power FSM control(Recommanded); 1 : AXI Low Power Interface of DDR Channel 3 'cactive_chn3';" "AXI Low Power FSM control(Recommanded);,AXI Low Power Interface of DDR Channel"
      BITFLD.LONG 0x00 2. "    DDR_CHN2_CGM_SEL   , DDR Channel 2 Clock Gating Control: 0 : AXI Low Power FSM control(Recommanded); 1 : AXI Low Power Interface of DDR Channel 2 'cactive_chn2';" "AXI Low Power FSM control(Recommanded);,AXI Low Power Interface of DDR Channel"
      BITFLD.LONG 0x00 1. "    DDR_CHN1_CGM_SEL   , DDR Channel 1 Clock Gating Control: 0 : AXI Low Power FSM control(Recommanded); 1 : AXI Low Power Interface of DDR Channel 1 'cactive_chn1';" "AXI Low Power FSM control(Recommanded);,AXI Low Power Interface of DDR Channel"
      BITFLD.LONG 0x00 0. "    DDR_CHN0_CGM_SEL   , DDR Channel 0 Clock Gating Control: 0 : AXI Low Power FSM control(Recommanded); 1 : AXI Low Power Interface of DDR Channel 0 'cactive_chn0';" "AXI Low Power FSM control(Recommanded);,AXI Low Power Interface of DDR Channel"
      TEXTLINE "                                            "
  GROUP.LONG 0x00FC++0x3 "0x402B0000 + 0x00FC"
    LINE.LONG 0x00 "DDR_CHN_SLEEP_CTRL1"
      BITFLD.LONG 0x00 9. "  DDR_CHN9_AXI_STOP_SEL , DDR Channel 9 AXI Stop control. 0 : AXI Clock stopped when in light sleep; 1 : AXI Clock Stopped when in Deep Sleep;" "AXI Clock stopped when in light sleep;,AXI Clock Stopped when in Deep Sleep;"
      BITFLD.LONG 0x00 8. "  DDR_CHN8_AXI_STOP_SEL , DDR Channel 8 AXI Stop control. 0 : AXI Clock stopped when in light sleep; 1 : AXI Clock Stopped when in Deep Sleep;" "AXI Clock stopped when in light sleep;,AXI Clock Stopped when in Deep Sleep;"
      BITFLD.LONG 0x00 7. "  DDR_CHN7_AXI_STOP_SEL , DDR Channel 7 AXI Stop control. 0 : AXI Clock stopped when in light sleep; 1 : AXI Clock Stopped when in Deep Sleep;" "AXI Clock stopped when in light sleep;,AXI Clock Stopped when in Deep Sleep;"
      BITFLD.LONG 0x00 6. "  DDR_CHN6_AXI_STOP_SEL , DDR Channel 6 AXI Stop control. 0 : AXI Clock stopped when in light sleep; 1 : AXI Clock Stopped when in Deep Sleep;" "AXI Clock stopped when in light sleep;,AXI Clock Stopped when in Deep Sleep;"
      TEXTLINE "                                            "
      BITFLD.LONG 0x00 5. "  DDR_CHN5_AXI_STOP_SEL , DDR Channel 5 AXI Stop control. 0 : AXI Clock stopped when in light sleep; 1 : AXI Clock Stopped when in Deep Sleep;" "AXI Clock stopped when in light sleep;,AXI Clock Stopped when in Deep Sleep;"
      BITFLD.LONG 0x00 4. "  DDR_CHN4_AXI_STOP_SEL , DDR Channel 4 AXI Stop control. 0 : AXI Clock stopped when in light sleep; 1 : AXI Clock Stopped when in Deep Sleep;" "AXI Clock stopped when in light sleep;,AXI Clock Stopped when in Deep Sleep;"
      BITFLD.LONG 0x00 3. "  DDR_CHN3_AXI_STOP_SEL , DDR Channel 3 AXI Stop control. 0 : AXI Clock stopped when in light sleep; 1 : AXI Clock Stopped when in Deep Sleep;" "AXI Clock stopped when in light sleep;,AXI Clock Stopped when in Deep Sleep;"
      BITFLD.LONG 0x00 2. "  DDR_CHN2_AXI_STOP_SEL , DDR Channel 2 AXI Stop control. 0 : AXI Clock stopped when in light sleep; 1 : AXI Clock Stopped when in Deep Sleep;" "AXI Clock stopped when in light sleep;,AXI Clock Stopped when in Deep Sleep;"
      TEXTLINE "                                            "
      BITFLD.LONG 0x00 1. "  DDR_CHN1_AXI_STOP_SEL , DDR Channel 1 AXI Stop control. 0 : AXI Clock stopped when in light sleep; 1 : AXI Clock Stopped when in Deep Sleep;" "AXI Clock stopped when in light sleep;,AXI Clock Stopped when in Deep Sleep;"
      BITFLD.LONG 0x00 0. "  DDR_CHN0_AXI_STOP_SEL , DDR Channel 0 AXI Stop control. 0 : AXI Clock stopped when in light sleep; 1 : AXI Clock Stopped when in Deep Sleep;" "AXI Clock stopped when in light sleep;,AXI Clock Stopped when in Deep Sleep;"
  GROUP.LONG 0x012C++0x3 "0x402B0000 + 0x012C"
    LINE.LONG 0x00 "DDR_OP_MODE_CFG"
      BITFLD.LONG 0x00 29.--31. "  Reserved         , " "Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved"
      BITFLD.LONG 0x00 28. "  DDR_OPERATE_MODE_BUSY , " "0,1"
      BITFLD.LONG 0x00 27. "                           DDR_PUBL_RET_EN          , Enable PWR_ST FSM to assert 'pd_save'/'pd_restore_n' signal. 0 : Disable; 1 : Enable;" "Disable;,Enable;"
      BITFLD.LONG 0x00 26. "  DDR_PHY_ISO_RST_EN , Reset 'DDR_PHY_RET_EN' with isolation signal of Power Domain 'PD_PUB_SYS'." "0,1"
      TEXTLINE "                                            "
      BITFLD.LONG 0x00 25. "  DDR_UMCTL_RET_EN , Enable PWR_ST FSM to assert 'pd_save'/'pd_restore_n' signal. 0 : Disable; 1 : Enable;" "Disable;,Enable;"
      BITFLD.LONG 0x00 24. "  DDR_PHY_AUTO_RET_EN   , DDR PHY Retenton enable. 0 : Disable DDR PHY Retention. 1 : Enable DDR PHY Retention." "Disable DDR PHY Retention.,Enable DDR PHY Retention."
      BITFLD.LONG 0x00 16.--23. "  DDR_OPERATE_MODE_CNT_LMT , Count Number wait for 'ddr_operate_mode' stable." "none"
      BITFLD.LONG 0x00 11.--15. "          Reserved           , " "Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved"
      TEXTLINE "                                            "
      BITFLD.LONG 0x00 8.--10. "  DDR_OPERATE_MODE , ddr_operate_mode' status." "0,1,2,3,4,5,6,7"
      BITFLD.LONG 0x00 3.--7. "         Reserved              , " "Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved"
      BITFLD.LONG 0x00 0.--2. "                    DDR_OPERATE_MODE_IDLE    , Configure value for 'ddr_operate_mode' to indicate idle." "0,1,2,3,4,5,6,7"
  GROUP.LONG 0x0130++0x3 "0x402B0000 + 0x0130"
    LINE.LONG 0x00 "DDR_PHY_RET_CFG"
      BITFLD.LONG 0x00 16. "  DDR_UMCTL_SOFT_RST , DDR UMCTL Soft Reset. Active High; 0 : Keep DDR UMCTL in normal mode; 1 : Reset DDR UMCTL;" "Keep DDR UMCTL in normal mode;,Reset DDR UMCTL;"
      BITFLD.LONG 0x00 0. "  DDR_PHY_CKE_RET_EN , DDR PHY 'RET' and 'RET_i' control bit. Only effective when 'DDR_PHY_AUTO_RET_EN' asserted." "0,1"
  GROUP.LONG 0x0134++0x3 "0x402B0000 + 0x0134"
    LINE.LONG 0x00 "26M_SEL_CFG"
      BITFLD.LONG 0x00 8. "  AON_RC_4M_SEL , AON RC 4M Source select: 0 : RC0; 1 : RC1" "RC,RC"
      BITFLD.LONG 0x00 7. "  Reserved , " "Reserved,Reserved"
      BITFLD.LONG 0x00 6. "  GGE_26M_SEL , GGE 26M Source select: 0 : RF0; 1 : RF1" "RF,RF"
      BITFLD.LONG 0x00 5. "  PUB_26M_SEL , PUB 26M Source select: 0 : RF0; 1 : RF1" "RF,RF"
      TEXTLINE "                                            "
      BITFLD.LONG 0x00 4. "  AON_26M_SEL   , AON 26M Source select: 0 : RF0; 1 : RF1" "RF,RF"
      BITFLD.LONG 0x00 3. "  Reserved , " "Reserved,Reserved"
      BITFLD.LONG 0x00 2. "  CP1_26M_SEL , CP1 26M Source select: 0 : RF0; 1 : RF1" "RF,RF"
      BITFLD.LONG 0x00 1. "  CP0_26M_SEL , CP0 26M Source select: 0 : RF0; 1 : RF1" "RF,RF"
      TEXTLINE "                                            "
      BITFLD.LONG 0x00 0. "  AP_26M_SEL    , AP 26M Source select: 0 : RF0; 1 : RF1" "RF,RF"
  GROUP.LONG 0x0138++0x3 "0x402B0000 + 0x0138"
    LINE.LONG 0x00 "BISR_DONE_STATUS"
      BITFLD.LONG 0x00 21. "  PD_CP1_COMWRAP_BISR_DONE , " "0,1"
      BITFLD.LONG 0x00 20. "  PD_CP1_LTE_P2_BISR_DONE , " "0,1"
      BITFLD.LONG 0x00 19. "         PD_CP1_LTE_P1_BISR_DONE , " "0,1"
      BITFLD.LONG 0x00 18. "  PD_CP1_CEVA_BISR_DONE   , " "0,1"
      TEXTLINE "                                            "
      BITFLD.LONG 0x00 17. "  PD_CP1_CA5_BISR_DONE     , " "0,1"
      BITFLD.LONG 0x00 16. "  Reserved                , " "Reserved,Reserved"
      BITFLD.LONG 0x00 15. "  PD_CP0_HU3GE_BISR_DONE  , " "0,1"
      BITFLD.LONG 0x00 14. "  PD_CP0_TD_BISR_DONE     , " "0,1"
      TEXTLINE "                                            "
      BITFLD.LONG 0x00 13. "  PD_CP0_GSM_1_BISR_DONE   , " "0,1"
      BITFLD.LONG 0x00 12. "  PD_CP0_GSM_0_BISR_DONE  , " "0,1"
      BITFLD.LONG 0x00 11. "         PD_CP0_CEVA_1_BISR_DONE , " "0,1"
      BITFLD.LONG 0x00 10. "  PD_CP0_CEVA_0_BISR_DONE , " "0,1"
      TEXTLINE "                                            "
      BITFLD.LONG 0x00 9. "  PD_CP0_ARM9_1_BISR_DONE  , " "0,1"
      BITFLD.LONG 0x00 8. "  PD_CP0_ARM9_0_BISR_DONE , " "0,1"
      BITFLD.LONG 0x00 7. "         PD_MM_TOP_BISR_DONE     , " "0,1"
      BITFLD.LONG 0x00 6. "  PD_GPU_TOP_BISR_DONE    , " "0,1"
      TEXTLINE "                                            "
      BITFLD.LONG 0x00 5. "  PD_AP_SYS_BISR_DONE      , " "0,1"
      BITFLD.LONG 0x00 4. "  PD_CA7_TOP_BISR_DONE    , " "0,1"
      BITFLD.LONG 0x00 3. "         PD_CA7_C3_BISR_DONE     , " "0,1"
      BITFLD.LONG 0x00 2. "  PD_CA7_C2_BISR_DONE     , " "0,1"
      TEXTLINE "                                            "
      BITFLD.LONG 0x00 1. "  PD_CA7_C1_BISR_DONE      , " "0,1"
      BITFLD.LONG 0x00 0. "  PD_CA7_C0_BISR_DONE     , " "0,1"
  GROUP.LONG 0x013C++0x3 "0x402B0000 + 0x013C"
    LINE.LONG 0x00 "BISR_BUSY_STATUS"
      BITFLD.LONG 0x00 21. "  PD_CP1_COMWRAP_BISR_BUSY , " "0,1"
      BITFLD.LONG 0x00 20. "  PD_CP1_LTE_P2_BISR_BUSY , " "0,1"
      BITFLD.LONG 0x00 19. "         PD_CP1_LTE_P1_BISR_BUSY , " "0,1"
      BITFLD.LONG 0x00 18. "  PD_CP1_CEVA_BISR_BUSY   , " "0,1"
      TEXTLINE "                                            "
      BITFLD.LONG 0x00 17. "  PD_CP1_CA5_BISR_BUSY     , " "0,1"
      BITFLD.LONG 0x00 16. "  Reserved                , " "Reserved,Reserved"
      BITFLD.LONG 0x00 15. "  PD_CP0_HU3GE_BISR_BUSY  , " "0,1"
      BITFLD.LONG 0x00 14. "  PD_CP0_TD_BISR_BUSY     , " "0,1"
      TEXTLINE "                                            "
      BITFLD.LONG 0x00 13. "  PD_CP0_GSM_1_BISR_BUSY   , " "0,1"
      BITFLD.LONG 0x00 12. "  PD_CP0_GSM_0_BISR_BUSY  , " "0,1"
      BITFLD.LONG 0x00 11. "         PD_CP0_CEVA_1_BISR_BUSY , " "0,1"
      BITFLD.LONG 0x00 10. "  PD_CP0_CEVA_0_BISR_BUSY , " "0,1"
      TEXTLINE "                                            "
      BITFLD.LONG 0x00 9. "  PD_CP0_ARM9_1_BISR_BUSY  , " "0,1"
      BITFLD.LONG 0x00 8. "  PD_CP0_ARM9_0_BISR_BUSY , " "0,1"
      BITFLD.LONG 0x00 7. "         PD_MM_TOP_BISR_BUSY     , " "0,1"
      BITFLD.LONG 0x00 6. "  PD_GPU_TOP_BISR_BUSY    , " "0,1"
      TEXTLINE "                                            "
      BITFLD.LONG 0x00 5. "  PD_AP_SYS_BISR_BUSY      , " "0,1"
      BITFLD.LONG 0x00 4. "  PD_CA7_TOP_BISR_BUSY    , " "0,1"
      BITFLD.LONG 0x00 3. "         PD_CA7_C3_BISR_BUSY     , " "0,1"
      BITFLD.LONG 0x00 2. "  PD_CA7_C2_BISR_BUSY     , " "0,1"
      TEXTLINE "                                            "
      BITFLD.LONG 0x00 1. "  PD_CA7_C1_BISR_BUSY      , " "0,1"
      BITFLD.LONG 0x00 0. "  PD_CA7_C0_BISR_BUSY     , " "0,1"
  GROUP.LONG 0x0140++0x3 "0x402B0000 + 0x0140"
    LINE.LONG 0x00 "BISR_BYP_CFG"
      BITFLD.LONG 0x00 21. "  PD_CP1_COMWRAP_BISR_FORCE_BYP , " "0,1"
      BITFLD.LONG 0x00 20. "  PD_CP1_LTE_P2_BISR_FORCE_BYP , " "0,1"
      BITFLD.LONG 0x00 19. "         PD_CP1_LTE_P1_BISR_FORCE_BYP , " "0,1"
      BITFLD.LONG 0x00 18. "  PD_CP1_CEVA_BISR_FORCE_BYP   , " "0,1"
      TEXTLINE "                                            "
      BITFLD.LONG 0x00 17. "  PD_CP1_CA5_BISR_FORCE_BYP     , " "0,1"
      BITFLD.LONG 0x00 16. "  Reserved                     , " "Reserved,Reserved"
      BITFLD.LONG 0x00 15. "  PD_CP0_HU3GE_BISR_FORCE_BYP  , " "0,1"
      BITFLD.LONG 0x00 14. "  PD_CP0_TD_BISR_FORCE_BYP     , " "0,1"
      TEXTLINE "                                            "
      BITFLD.LONG 0x00 13. "  PD_CP0_GSM_1_BISR_FORCE_BYP   , " "0,1"
      BITFLD.LONG 0x00 12. "  PD_CP0_GSM_0_BISR_FORCE_BYP  , " "0,1"
      BITFLD.LONG 0x00 11. "         PD_CP0_CEVA_1_BISR_FORCE_BYP , " "0,1"
      BITFLD.LONG 0x00 10. "  PD_CP0_CEVA_0_BISR_FORCE_BYP , " "0,1"
      TEXTLINE "                                            "
      BITFLD.LONG 0x00 9. "  PD_CP0_ARM9_1_BISR_FORCE_BYP  , " "0,1"
      BITFLD.LONG 0x00 8. "  PD_CP0_ARM9_0_BISR_FORCE_BYP , " "0,1"
      BITFLD.LONG 0x00 7. "         PD_MM_TOP_BISR_FORCE_BYP     , " "0,1"
      BITFLD.LONG 0x00 6. "  PD_GPU_TOP_BISR_FORCE_BYP    , " "0,1"
      TEXTLINE "                                            "
      BITFLD.LONG 0x00 5. "  PD_AP_SYS_BISR_FORCE_BYP      , " "0,1"
      BITFLD.LONG 0x00 4. "  PD_CA7_TOP_BISR_FORCE_BYP    , " "0,1"
      BITFLD.LONG 0x00 3. "         PD_CA7_C3_BISR_FORCE_BYP     , " "0,1"
      BITFLD.LONG 0x00 2. "  PD_CA7_C2_BISR_FORCE_BYP     , " "0,1"
      TEXTLINE "                                            "
      BITFLD.LONG 0x00 1. "  PD_CA7_C1_BISR_FORCE_BYP      , " "0,1"
      BITFLD.LONG 0x00 0. "  PD_CA7_C0_BISR_FORCE_BYP     , " "0,1"
  GROUP.LONG 0x0144++0x3 "0x402B0000 + 0x0144"
    LINE.LONG 0x00 "BISR_EN_CFG"
      BITFLD.LONG 0x00 21. "  PD_CP1_COMWRAP_BISR_FORCE_EN , " "0,1"
      BITFLD.LONG 0x00 20. "  PD_CP1_LTE_P2_BISR_FORCE_EN , " "0,1"
      BITFLD.LONG 0x00 19. "         PD_CP1_LTE_P1_BISR_FORCE_EN , " "0,1"
      BITFLD.LONG 0x00 18. "  PD_CP1_CEVA_BISR_FORCE_EN   , " "0,1"
      TEXTLINE "                                            "
      BITFLD.LONG 0x00 17. "  PD_CP1_CA5_BISR_FORCE_EN     , " "0,1"
      BITFLD.LONG 0x00 16. "  Reserved                    , " "Reserved,Reserved"
      BITFLD.LONG 0x00 15. "  PD_CP0_HU3GE_BISR_FORCE_EN  , " "0,1"
      BITFLD.LONG 0x00 14. "  PD_CP0_TD_BISR_FORCE_EN     , " "0,1"
      TEXTLINE "                                            "
      BITFLD.LONG 0x00 13. "  PD_CP0_GSM_1_BISR_FORCE_EN   , " "0,1"
      BITFLD.LONG 0x00 12. "  PD_CP0_GSM_0_BISR_FORCE_EN  , " "0,1"
      BITFLD.LONG 0x00 11. "         PD_CP0_CEVA_1_BISR_FORCE_EN , " "0,1"
      BITFLD.LONG 0x00 10. "  PD_CP0_CEVA_0_BISR_FORCE_EN , " "0,1"
      TEXTLINE "                                            "
      BITFLD.LONG 0x00 9. "  PD_CP0_ARM9_1_BISR_FORCE_EN  , " "0,1"
      BITFLD.LONG 0x00 8. "  PD_CP0_ARM9_0_BISR_FORCE_EN , " "0,1"
      BITFLD.LONG 0x00 7. "         PD_MM_TOP_BISR_FORCE_EN     , " "0,1"
      BITFLD.LONG 0x00 6. "  PD_GPU_TOP_BISR_FORCE_EN    , " "0,1"
      TEXTLINE "                                            "
      BITFLD.LONG 0x00 5. "  PD_AP_SYS_BISR_FORCE_EN      , " "0,1"
      BITFLD.LONG 0x00 4. "  PD_CA7_TOP_BISR_FORCE_EN    , " "0,1"
      BITFLD.LONG 0x00 3. "         PD_CA7_C3_BISR_FORCE_EN     , " "0,1"
      BITFLD.LONG 0x00 2. "  PD_CA7_C2_BISR_FORCE_EN     , " "0,1"
      TEXTLINE "                                            "
      BITFLD.LONG 0x00 1. "  PD_CA7_C1_BISR_FORCE_EN      , " "0,1"
      BITFLD.LONG 0x00 0. "  PD_CA7_C0_BISR_FORCE_EN     , " "0,1"
  GROUP.LONG 0x0148++0x3 "0x402B0000 + 0x0148"
    LINE.LONG 0x00 "CGM_AUTO_GATE_SEL_CFG0"
  GROUP.LONG 0x014C++0x3 "0x402B0000 + 0x014C"
    LINE.LONG 0x00 "CGM_AUTO_GATE_SEL_CFG1"
  GROUP.LONG 0x0150++0x3 "0x402B0000 + 0x0150"
    LINE.LONG 0x00 "CGM_AUTO_GATE_SEL_CFG2"
  GROUP.LONG 0x0154++0x3 "0x402B0000 + 0x0154"
    LINE.LONG 0x00 "CGM_AUTO_GATE_SEL_CFG3"
  GROUP.LONG 0x0158++0x3 "0x402B0000 + 0x0158"
    LINE.LONG 0x00 "CGM_FORCE_EN_CFG0"
  GROUP.LONG 0x015C++0x3 "0x402B0000 + 0x015C"
    LINE.LONG 0x00 "CGM_FORCE_EN_CFG1"
  GROUP.LONG 0x0160++0x3 "0x402B0000 + 0x0160"
    LINE.LONG 0x00 "CGM_FORCE_EN_CFG2"
  GROUP.LONG 0x0164++0x3 "0x402B0000 + 0x0164"
    LINE.LONG 0x00 "CGM_FORCE_EN_CFG3"
  GROUP.LONG 0x0168++0x3 "0x402B0000 + 0x0168"
    LINE.LONG 0x00 "SLEEP_XTLON_CTRL"
      BITFLD.LONG 0x00 5. "  ARM7_SLEEP_XTL_ON , XTL0 or/and XTL1, which ARM7 selected, kept on when ARM7 in Deep slee; 0 : XTL0 or/and XTL1 shut down in ARM71 sleep; 1 : XTL0 or/and XTL1 kept on in ARM7 sleep;" "XTL,XTL"
      BITFLD.LONG 0x00 4. "  VCP1_SLEEP_XTL_ON , XTL0 or/and XTL1, which VCP1 selected, kept on when CP1 in Deep slee; 0 : XTL0 or/and XTL1 shut down in VCP1 sleep; 1 : XTL0 or/and XTL1 kept on in VCP1 sleep;" "XTL,XTL"
      BITFLD.LONG 0x00 3. "  VCP0_SLEEP_XTL_ON , XTL0 or/and XTL1, which VCP0 selected, kept on when CP0 in Deep slee; 0 : XTL0 or/and XTL1 shut down in VCP0 sleep; 1 : XTL0 or/and XTL1 kept on in VCP0 sleep;" "XTL,XTL"
      BITFLD.LONG 0x00 2. "  CP1_SLEEP_XTL_ON , XTL0 or/and XTL1, which CP1 selected, kept on when CP1 in Deep slee; 0 : XTL0 or/and XTL1 shut down in CP1 sleep; 1 : XTL0 or/and XTL1 kept on in CP1 sleep;" "XTL,XTL"
      TEXTLINE "                                            "
      BITFLD.LONG 0x00 1. "  CP0_SLEEP_XTL_ON  , XTL0 or/and XTL1, which CP0 selected, kept on when CP0 in Deep slee; 0 : XTL0 or/and XTL1 shut down in CP0 sleep; 1 : XTL0 or/and XTL1 kept on in CP0 sleep;" "XTL,XTL"
      BITFLD.LONG 0x00 0. "  AP_SLEEP_XTL_ON   , XTL0 or/and XTL1, which AP selected, kept on when AP in Deep slee; 0 : XTL0 or/and XTL1 shut down in AP sleep; 1 : XTL0 or/and XTL1 kept on in AP sleep;" "XTL,XTL"
  GROUP.LONG 0x016C++0x3 "0x402B0000 + 0x016C"
    LINE.LONG 0x00 "MEM_SLP_CFG"
  GROUP.LONG 0x0170++0x3 "0x402B0000 + 0x0170"
    LINE.LONG 0x00 "MEM_SD_CFG"
  GROUP.LONG 0x0174++0x3 "0x402B0000 + 0x0174"
    LINE.LONG 0x00 "CA7_CORE_PU_LOCK"
      BITFLD.LONG 0x00 11. "  CA7_C3_GIC_WAKEUP_EN , " "0,1"
      BITFLD.LONG 0x00 10. "         CA7_C2_GIC_WAKEUP_EN , " "0,1"
      BITFLD.LONG 0x00 9. "  CA7_C1_GIC_WAKEUP_EN , " "0,1"
      BITFLD.LONG 0x00 8. "  CA7_C0_GIC_WAKEUP_EN , " "0,1"
      TEXTLINE "                                            "
      BITFLD.LONG 0x00 4.--7. "  Reserved             , " "Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved"
      BITFLD.LONG 0x00 3. "  CA7_C3_PU_LOCK       , " "0,1"
      BITFLD.LONG 0x00 2. "  CA7_C2_PU_LOCK       , " "0,1"
      BITFLD.LONG 0x00 1. "  CA7_C1_PU_LOCK       , " "0,1"
      TEXTLINE "                                            "
      BITFLD.LONG 0x00 0. "  CA7_C0_PU_LOCK       , " "0,1"
  GROUP.LONG 0x0178++0x3 "0x402B0000 + 0x0178"
    LINE.LONG 0x00 "ARM7_HOLD_CGM_EN"
      BITFLD.LONG 0x00 10. "  PD_CP1_CEVA_CGM_HOLD_EN   , " "0,1"
      BITFLD.LONG 0x00 9. "  PD_CP1_CA5_CGM_HOLD_EN    , " "0,1"
      BITFLD.LONG 0x00 8. "  PD_CP0_CEVA_1_CGM_HOLD_EN , " "0,1"
      BITFLD.LONG 0x00 7. "  PD_CP0_CEVA_0_CGM_HOLD_EN , " "0,1"
      TEXTLINE "                                            "
      BITFLD.LONG 0x00 6. "  PD_CP0_ARM9_1_CGM_HOLD_EN , " "0,1"
      BITFLD.LONG 0x00 5. "  PD_CP0_ARM9_0_CGM_HOLD_EN , " "0,1"
      BITFLD.LONG 0x00 4. "  PD_CA7_TOP_CMG_HOLD_EN    , " "0,1"
      BITFLD.LONG 0x00 3. "  PD_CA7_C3_CMG_HOLD_EN     , " "0,1"
      TEXTLINE "                                            "
      BITFLD.LONG 0x00 2. "  PD_CA7_C2_CMG_HOLD_EN     , " "0,1"
      BITFLD.LONG 0x00 1. "  PD_CA7_C1_CMG_HOLD_EN     , " "0,1"
      BITFLD.LONG 0x00 0. "  PD_CA7_C0_CMG_HOLD_EN     , " "0,1"
  GROUP.LONG 0x017C++0x3 "0x402B0000 + 0x017C"
    LINE.LONG 0x00 "PWR_CNT_WAIT_CFG0"
      BITFLD.LONG 0x00 24.--31. "  VCP0_PWR_WAIT_CNT , " "none"
      BITFLD.LONG 0x00 16.--23. "  CP1_PWR_WAIT_CNT , " "none"
      BITFLD.LONG 0x00 8.--15. "  CP0_PWR_WAIT_CNT , " "none"
      BITFLD.LONG 0x00 0.--7. "  AP_PWR_WAIT_CNT , 1ms power stable wait time, by default;" "none"
      TEXTLINE "                                            "
  GROUP.LONG 0x0180++0x3 "0x402B0000 + 0x0180"
    LINE.LONG 0x00 "PWR_CNT_WAIT_CFG1"
      BITFLD.LONG 0x00 8.--15. "  ARM7_PWR_WAIT_CNT , " "none"
      BITFLD.LONG 0x00 0.--7. "  VCP1_PWR_WAIT_CNT , " "none"
  GROUP.LONG 0x0184++0x3 "0x402B0000 + 0x0184"
    LINE.LONG 0x00 "RC0_REL_CFG"
      BITFLD.LONG 0x00 5. "  RC0_ARM7_SEL , RC0 selected by ARM7 sys. Once selected, RC0 would SHUTDOWN after ARM7 sys into deep sleep; 0 :RC0 not selected by ARM7 sys; 1 : RC0 selected by ARM7 Sys." "RC,RC"
      BITFLD.LONG 0x00 4. "  RC0_VCP1_SEL , RC0 selected by VCP1 sys. Once selected, RC0 would SHUTDOWN after VCP1 sys into deep sleep; 0 : RC0 not selected by VCP1 sys; 1 : RC0 selected by VCP1 Sys." "RC,RC"
      BITFLD.LONG 0x00 3. "  RC0_VCP0_SEL , RC0 selected by VCP0 sys. Once selected, RC0 would SHUTDOWN after VCP0 sys into deep sleep; 0 : RC0 not selected by VCP0 sys; 1 : RC0 selected by VCP0 Sys." "RC,RC"
      BITFLD.LONG 0x00 2. "  RC0_CP1_SEL , RC0 selected by CP1 sys. Once selected, RC0 would SHUTDOWN after CP1 sys into deep sleep; 0 : RC0 not selected by CP1 sys; 1 : RC0 selected by CP1 Sys." "RC,RC"
      TEXTLINE "                                            "
      BITFLD.LONG 0x00 1. "  RC0_CP0_SEL  , RC0 selected by CP0 sys. Once selected, RC0 would SHUTDOWN after CP0 sys into deep sleep; 0 : RC0 not selected by CP0 sys; 1 : RC0 selected by CP0 Sys." "RC,RC"
      BITFLD.LONG 0x00 0. "  RC0_AP_SEL   , RC0 selected by AP sys. Once selected, RC0 would SHUTDOWN after AP sys into deep sleep; 0 : RC0 not selected by AP sys; 1 : RC0 selected by AP Sys." "RC,RC"
  GROUP.LONG 0x0188++0x3 "0x402B0000 + 0x0188"
    LINE.LONG 0x00 "RC1_REL_CFG"
      BITFLD.LONG 0x00 5. "  RC1_ARM7_SEL , RC1 selected by ARM7 sys. Once selected, RC1 would SHUTDOWN after ARM7 sys into deep sleep; 0 :RC1 not selected by ARM7 sys; 1 : RC1 selected by ARM7 Sys." "RC,RC"
      BITFLD.LONG 0x00 4. "  RC1_VCP1_SEL , RC1 selected by VCP1 sys. Once selected, RC1 would SHUTDOWN after VCP1 sys into deep sleep; 0 : RC1 not selected by VCP1 sys; 1 : RC1 selected by VCP1 Sys." "RC,RC"
      BITFLD.LONG 0x00 3. "  RC1_VCP0_SEL , RC1 selected by VCP0 sys. Once selected, RC1 would SHUTDOWN after VCP0 sys into deep sleep; 0 : RC1 not selected by VCP0 sys; 1 : RC1 selected by VCP0 Sys." "RC,RC"
      BITFLD.LONG 0x00 2. "  RC1_CP1_SEL , RC1 selected by CP1 sys. Once selected, RC1 would SHUTDOWN after CP1 sys into deep sleep; 0 : RC1 not selected by CP1 sys; 1 : RC1 selected by CP1 Sys." "RC,RC"
      TEXTLINE "                                            "
      BITFLD.LONG 0x00 1. "  RC1_CP0_SEL  , RC1 selected by CP0 sys. Once selected, RC1 would SHUTDOWN after CP0 sys into deep sleep; 0 : RC1 not selected by CP0 sys; 1 : RC1 selected by CP0 Sys." "RC,RC"
      BITFLD.LONG 0x00 0. "  RC1_AP_SEL   , RC1 selected by AP sys. Once selected, RC1 would SHUTDOWN after AP sys into deep sleep; 0 : RC1 not selected by AP sys; 1 : RC1 selected by AP Sys." "RC,RC"
  GROUP.LONG 0x018C++0x3 "0x402B0000 + 0x018C"
    LINE.LONG 0x00 "RC_CNT_WAIT_CFG"
      BITFLD.LONG 0x00 8.--15. "  RC1_WAIT_CNT , " "none"
      BITFLD.LONG 0x00 0.--7. "  RC0_WAIT_CNT , 1ms power stable wait time, by default;" "none"
  GROUP.LONG 0x0190++0x3 "0x402B0000 + 0x0190"
    LINE.LONG 0x00 "MEM_AUTO_SLP_CFG"
  GROUP.LONG 0x0194++0x3 "0x402B0000 + 0x0194"
    LINE.LONG 0x00 "MEM_AUTO_SD_CFG"
  GROUP.LONG 0x0198++0x3 "0x402B0000 + 0x0198"
    LINE.LONG 0x00 "CP0_PD_SHUTDOWN_CFG"
      BITFLD.LONG 0x00 20. "  PD_CP0_HU3GE_VCP1_SEL  , " "0,1"
      BITFLD.LONG 0x00 19. "  PD_CP0_TD_VCP1_SEL    , " "0,1"
      BITFLD.LONG 0x00 18. "         PD_CP0_GSM_0_VCP1_SEL  , " "0,1"
      BITFLD.LONG 0x00 17. "  PD_CP0_CEVA_0_VCP1_SEL , " "0,1"
      TEXTLINE "                                            "
      BITFLD.LONG 0x00 16. "  PD_CP0_ARM9_1_VCP1_SEL , " "0,1"
      BITFLD.LONG 0x00 9.--15. "  Reserved              , " "Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved"
      BITFLD.LONG 0x00 8. "  PD_CP0_ARM9_0_VCP0_SEL , " "0,1"
      BITFLD.LONG 0x00 6.--7. "  Reserved               , " "Reserved,Reserved,Reserved,Reserved"
      TEXTLINE "                                            "
      BITFLD.LONG 0x00 5. "  PD_CP0_HU3GE_CP0_SEL   , " "0,1"
      BITFLD.LONG 0x00 4. "  PD_CP0_TD_CP0_SEL     , " "0,1"
      BITFLD.LONG 0x00 3. "         PD_CP0_GSM_0_CP0_SEL   , " "0,1"
      BITFLD.LONG 0x00 2. "  PD_CP0_CEVA_0_CP0_SEL  , " "0,1"
      TEXTLINE "                                            "
      BITFLD.LONG 0x00 1. "  PD_CP0_ARM9_1_CP0_SEL  , " "0,1"
      BITFLD.LONG 0x00 0. "  PD_CP0_ARM9_0_CP0_SEL , " "0,1"
  GROUP.LONG 0x019C++0x3 "0x402B0000 + 0x019C"
    LINE.LONG 0x00 "CP1_PD_SHUTDOWN_CFG"
      BITFLD.LONG 0x00 20. "  PD_CP1_COMWRAP_VCP1_SEL , " "0,1"
      BITFLD.LONG 0x00 19. "  PD_CP1_CEVA_VCP1_SEL   , " "0,1"
      BITFLD.LONG 0x00 18. "  PD_CP1_LTE_P2_VCP1_SEL , " "0,1"
      BITFLD.LONG 0x00 17. "  PD_CP1_LTE_P1_VCP1_SEL , " "0,1"
      TEXTLINE "                                            "
      BITFLD.LONG 0x00 16. "  PD_CP1_CA5_VCP1_SEL     , " "0,1"
      BITFLD.LONG 0x00 4. "  PD_CP1_COMWRAP_CP1_SEL , " "0,1"
      BITFLD.LONG 0x00 3. "  PD_CP1_CEVA_CP1_SEL    , " "0,1"
      BITFLD.LONG 0x00 2. "  PD_CP1_LTE_P2_CP1_SEL  , " "0,1"
      TEXTLINE "                                            "
      BITFLD.LONG 0x00 1. "  PD_CP1_LTE_P1_CP1_SEL   , " "0,1"
      BITFLD.LONG 0x00 0. "  PD_CP1_CA5_CP1_SEL     , " "0,1"
  GROUP.LONG 0x01A0++0x3 "0x402B0000 + 0x01A0"
    LINE.LONG 0x00 "WAKEUP_LOCK_EN"
      BITFLD.LONG 0x00 27.--31. "  Reserved                     , " "Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved"
      BITFLD.LONG 0x00 26. "  VCP1_SYS_WAKEUP_LOCK_EN      , " "0,1"
      BITFLD.LONG 0x00 25. "  VCP0_SYS_WAKEUP_LOCK_EN      , " "0,1"
      BITFLD.LONG 0x00 24. "  CP1_SYS_WAKEUP_LOCK_EN        , " "0,1"
      TEXTLINE "                                            "
      BITFLD.LONG 0x00 23. "  CP0_SYS_WAKEUP_LOCK_EN       , " "0,1"
      BITFLD.LONG 0x00 22. "         AP_SYS_WAKEUP_LOCK_EN        , " "0,1"
      BITFLD.LONG 0x00 21. "  PD_PUB_SYS_WAKEUP_LOCK_EN    , " "0,1"
      BITFLD.LONG 0x00 20. "  PD_CP1_COMWRAP_WAKEUP_LOCK_EN , " "0,1"
      TEXTLINE "                                            "
      BITFLD.LONG 0x00 19. "  PD_CP1_CEVA_WAKEUP_LOCK_EN   , " "0,1"
      BITFLD.LONG 0x00 18. "         PD_CP1_LTE_P2_WAKEUP_LOCK_EN , " "0,1"
      BITFLD.LONG 0x00 17. "  PD_CP1_LTE_P1_WAKEUP_LOCK_EN , " "0,1"
      BITFLD.LONG 0x00 16. "  PD_CP1_CA5_WAKEUP_LOCK_EN     , " "0,1"
      TEXTLINE "                                            "
      BITFLD.LONG 0x00 15. "  PD_CP0_CEVA_1_WAKEUP_LOCK_EN , " "0,1"
      BITFLD.LONG 0x00 14. "         PD_CP0_CEVA_0_WAKEUP_LOCK_EN , " "0,1"
      BITFLD.LONG 0x00 13. "  PD_CP0_TD_WAKEUP_LOCK_EN     , " "0,1"
      BITFLD.LONG 0x00 12. "  PD_CP0_GSM_1_WAKEUP_LOCK_EN   , " "0,1"
      TEXTLINE "                                            "
      BITFLD.LONG 0x00 11. "  PD_CP0_GSM_0_WAKEUP_LOCK_EN  , " "0,1"
      BITFLD.LONG 0x00 10. "         PD_CP0_HU3GE_WAKEUP_LOCK_EN  , " "0,1"
      BITFLD.LONG 0x00 9. "  PD_CP0_ARM9_1_WAKEUP_LOCK_EN , " "0,1"
      BITFLD.LONG 0x00 8. "  PD_CP0_ARM9_0_WAKEUP_LOCK_EN  , " "0,1"
      TEXTLINE "                                            "
      BITFLD.LONG 0x00 7. "  PD_MM_TOP_WAKEUP_LOCK_EN     , " "0,1"
      BITFLD.LONG 0x00 6. "         PD_GPU_TOP_WAKEUP_LOCK_EN    , " "0,1"
      BITFLD.LONG 0x00 5. "  PD_AP_SYS_WAKEUP_LOCK_EN     , " "0,1"
      BITFLD.LONG 0x00 4. "  PD_CA7_TOP_WAKEUP_LOCK_EN     , " "0,1"
      TEXTLINE "                                            "
      BITFLD.LONG 0x00 3. "  PD_CA7_C3_WAKEUP_LOCK_EN     , " "0,1"
      BITFLD.LONG 0x00 2. "         PD_CA7_C2_WAKEUP_LOCK_EN     , " "0,1"
      BITFLD.LONG 0x00 1. "  PD_CA7_C1_WAKEUP_LOCK_EN     , " "0,1"
      BITFLD.LONG 0x00 0. "  PD_CA7_C0_WAKEUP_LOCK_EN      , " "0,1"
      TEXTLINE "                                            "
  GROUP.LONG 0x3000++0x3 "0x402B0000 + 0x3000"
    LINE.LONG 0x00 "PD_CA7_C0_SHUTDOWN_MARK_STATUS"
      BITFLD.LONG 0x00 0.--3. "  PD_CA7_C0_SHUTDOWN_MARK , " "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  GROUP.LONG 0x3004++0x3 "0x402B0000 + 0x3004"
    LINE.LONG 0x00 "PD_CA7_C1_SHUTDOWN_MARK_STATUS"
      BITFLD.LONG 0x00 0.--3. "  PD_CA7_C1_SHUTDOWN_MARK , " "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  GROUP.LONG 0x3008++0x3 "0x402B0000 + 0x3008"
    LINE.LONG 0x00 "PD_CA7_C2_SHUTDOWN_MARK_STATUS"
      BITFLD.LONG 0x00 0.--3. "  PD_CA7_C2_SHUTDOWN_MARK , " "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  GROUP.LONG 0x300C++0x3 "0x402B0000 + 0x300C"
    LINE.LONG 0x00 "PD_CA7_C3_SHUTDOWN_MARK_STATUS"
      BITFLD.LONG 0x00 0.--3. "  PD_CA7_C3_SHUTDOWN_MARK , " "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  GROUP.LONG 0x3010++0x3 "0x402B0000 + 0x3010"
    LINE.LONG 0x00 "PD_CA7_TOP_SHUTDOWN_MARK_STATUS"
      BITFLD.LONG 0x00 0.--3. "  PD_CA7_TOP_SHUTDOWN_MARK , " "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  GROUP.LONG 0x3014++0x3 "0x402B0000 + 0x3014"
    LINE.LONG 0x00 "PD_AP_SYS_SHUTDOWN_MARK_STATUS"
      BITFLD.LONG 0x00 0.--3. "  PD_AP_SYS_SHUTDOWN_MARK , " "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  GROUP.LONG 0x3018++0x3 "0x402B0000 + 0x3018"
    LINE.LONG 0x00 "PD_GPU_TOP_SHUTDOWN_MARK_STATUS"
      BITFLD.LONG 0x00 0.--3. "  PD_GPU_TOP_SHUTDOWN_MARK , " "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  GROUP.LONG 0x301C++0x3 "0x402B0000 + 0x301C"
    LINE.LONG 0x00 "PD_MM_TOP_SHUTDOWN_MARK_STATUS"
      BITFLD.LONG 0x00 0.--3. "  PD_MM_TOP_SHUTDOWN_MARK , " "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  GROUP.LONG 0x3020++0x3 "0x402B0000 + 0x3020"
    LINE.LONG 0x00 "PD_CP0_ARM9_0_SHUTDOWN_MARK_STATUS"
      BITFLD.LONG 0x00 0.--3. "  PD_CP0_ARM9_0_SHUTDOWN_MARK , " "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  GROUP.LONG 0x3024++0x3 "0x402B0000 + 0x3024"
    LINE.LONG 0x00 "PD_CP0_ARM9_1_SHUTDOWN_MARK_STATUS"
      BITFLD.LONG 0x00 0.--3. "  PD_CP0_ARM9_1_SHUTDOWN_MARK , " "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  GROUP.LONG 0x3028++0x3 "0x402B0000 + 0x3028"
    LINE.LONG 0x00 "PD_CP0_CEVA_0_SHUTDOWN_MARK_STATUS"
      BITFLD.LONG 0x00 0.--3. "  PD_CP0_CEVA_0_SHUTDOWN_MARK , " "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  GROUP.LONG 0x302C++0x3 "0x402B0000 + 0x302C"
    LINE.LONG 0x00 "PD_CP0_CEVA_1_SHUTDOWN_MARK_STATUS"
      BITFLD.LONG 0x00 0.--3. "  PD_CP0_CEVA_1_SHUTDOWN_MARK , " "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  GROUP.LONG 0x3030++0x3 "0x402B0000 + 0x3030"
    LINE.LONG 0x00 "PD_CP0_GSM_0_SHUTDOWN_MARK_STATUS"
      BITFLD.LONG 0x00 0.--3. "  PD_CP0_GSM_0_SHUTDOWN_MARK , " "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  GROUP.LONG 0x3034++0x3 "0x402B0000 + 0x3034"
    LINE.LONG 0x00 "PD_CP0_GSM_1_SHUTDOWN_MARK_STATUS"
      BITFLD.LONG 0x00 0.--3. "  PD_CP0_GSM_1_SHUTDOWN_MARK , " "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  GROUP.LONG 0x3038++0x3 "0x402B0000 + 0x3038"
    LINE.LONG 0x00 "PD_CP0_TD_SHUTDOWN_MARK_STATUS"
      BITFLD.LONG 0x00 0.--3. "  PD_CP0_TD_SHUTDOWN_MARK , " "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  GROUP.LONG 0x303C++0x3 "0x402B0000 + 0x303C"
    LINE.LONG 0x00 "PD_CP0_HU3GE_SHUTDOWN_MARK_STATUS"
      BITFLD.LONG 0x00 0.--3. "  PD_CP0_HU3GE_SHUTDOWN_MARK , " "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  GROUP.LONG 0x3040++0x3 "0x402B0000 + 0x3040"
    LINE.LONG 0x00 "PD_CP1_CA5_SHUTDOWN_MARK_STATUS"
      BITFLD.LONG 0x00 0.--3. "  PD_CP1_CA5_SHUTDOWN_MARK , " "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  GROUP.LONG 0x3044++0x3 "0x402B0000 + 0x3044"
    LINE.LONG 0x00 "PD_CP1_CEVA_SHUTDOWN_MARK_STATUS"
      BITFLD.LONG 0x00 0.--3. "  PD_CP1_CEVA_SHUTDOWN_MARK , " "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  GROUP.LONG 0x3048++0x3 "0x402B0000 + 0x3048"
    LINE.LONG 0x00 "PD_CP1_LTE_P1_SHUTDOWN_MARK_STATUS"
      BITFLD.LONG 0x00 0.--3. "  PD_CP1_LTE_P1_SHUTDOWN_MARK , " "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  GROUP.LONG 0x304C++0x3 "0x402B0000 + 0x304C"
    LINE.LONG 0x00 "PD_CP1_LTE_P2_SHUTDOWN_MARK_STATUS"
      BITFLD.LONG 0x00 0.--3. "  PD_CP1_LTE_P2_SHUTDOWN_MARK , " "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  GROUP.LONG 0x3050++0x3 "0x402B0000 + 0x3050"
    LINE.LONG 0x00 "PD_CP1_COMWRAP_SHUTDOWN_MARK_STATUS"
      BITFLD.LONG 0x00 0.--3. "  PD_CP1_COMWRAP_SHUTDOWN_MARK , " "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  GROUP.LONG 0x3054++0x3 "0x402B0000 + 0x3054"
    LINE.LONG 0x00 "PD_PUB_SYS_SHUTDOWN_MARK_STATUS"
      BITFLD.LONG 0x00 0.--3. "  PD_PUB_SYS_SHUTDOWN_MARK , " "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
TREE.END
