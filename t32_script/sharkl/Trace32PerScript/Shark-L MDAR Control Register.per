;This file is generated by Trace32PerBuilder Version: 0.5.3.
;  Please access external network Trace32 Per Builder Homepage for documents
;and source code.
;   http://wikiserver.spreadtrum.com/Projects/SoftwareSystem/wiki/BbDrvTools/Trace32PerBuilder

config 10. 8.
width 18.
TREE.open "SharkL - aon - mdar_apb_rf"
  BASE sd:0x02070000
  GROUP.LONG 0x0000++0x3 "0x02070000 + 0x0000"
    LINE.LONG 0x00 "MDAR_CFG0"
      BITFLD.LONG 0x00 31. "  MDAR_ADA_MODE , Reserved" "0,1"
      BITFLD.LONG 0x00 26.--30. "                             ADC3_CHANNEL_SSET , Set the bit high will force high the request to ADC3. bit[26] is set for LTE; bit[27] is set for TDSCDMA; bit[28] is set for GSM in TG; bit[29] is set for WCDMA; bit[30] is set for GSM in WG." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
      BITFLD.LONG 0x00 21.--25. "  ADC2_CHANNEL_SSET , Set the bit high will force high the request to ADC2.bit[21] is set for LTE; bit[22] is set for TDSCDMA; bit[23] is set for GSM in TG; bit[24] is set for WCDMA; bit[25] is set for GSM in WG." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
      BITFLD.LONG 0x00 16.--20. "  ADC1_CHANNEL_SSET , Set the bit high will force high the request to ADC1. bit[16] is set for LTE; bit[17] is set for TDSCDMA; bit[18] is set for GSM in TG; bit[19] is set for WCDMA; bit[20] is set for GSM in WG." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 15. "  MDAR_WTG_MODE , 0: the WCDMA is choosed as the 3G in the wtg subsystem. 0: theTDSCDMA is choosed as the 3G in the wtg subsystem." "theTDSCDMA is choosed as the,1"
      BITFLD.LONG 0x00 10.--14. "  ADC3_CHANNEL_MASK , Set the bit high will enable the request to ADC3.bit[10] is set for LTE; bit[11] is set for TDSCDMA; bit[12] is set for GSM in TG; bit[13] is set for WCDMA; bit[14] is set for GSM in WG." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
      BITFLD.LONG 0x00 5.--9. "  ADC2_CHANNEL_MASK , Set the bit high will enable the request to ADC2.bit[5] is set for LTE; bit[6] is set for TDSCDMA; bit[7] is set for GSM in TG; bit[8] is set for WCDMA; bit[9] is set for GSM in WG." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
      BITFLD.LONG 0x00 0.--4. "  ADC1_CHANNEL_MASK , Set the bit high will enable the request to ADC1.bit[0] is set for LTE; bit[1] is set for TDSCDMA; bit[2] is set for GSM in TG; bit[3] is set for WCDMA; bit[4] is set for GSM in WG." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
      TEXTLINE "                           "
  GROUP.LONG 0x0004++0x3 "0x02070000 + 0x0004"
    LINE.LONG 0x00 "MDAR_CFG1"
      BITFLD.LONG 0x00 31. "  Reserved , Reserved" "Reserved,Reserved"
      BITFLD.LONG 0x00 26.--30. "  DAC3_CHANNEL_SSET , Set the bit high will force high the request to DAC3. bit[26] is set for LTE; bit[27] is set for TDSCDMA; bit[28] is set for GSM in TG; bit[29] is set for WCDMA; bit[30] is set for GSM in WG." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
      BITFLD.LONG 0x00 21.--25. "  DAC2_CHANNEL_SSET , Set the bit high will force high the request to DAC2.bit[21] is set for LTE; bit[22] is set for TDSCDMA; bit[23] is set for GSM in TG; bit[24] is set for WCDMA; bit[25] is set for GSM in WG." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
      BITFLD.LONG 0x00 16.--20. "  DAC1_CHANNEL_SSET , Set the bit high will force high the request to DAC1. bit[16] is set for LTE; bit[17] is set for TDSCDMA; bit[18] is set for GSM in TG; bit[19] is set for WCDMA; bit[20] is set for GSM in WG." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 15. "  Reserved , Reserved" "Reserved,Reserved"
      BITFLD.LONG 0x00 10.--14. "  DAC3_CHANNEL_MASK , Set the bit high will enable the request to DAC3.bit[10] is set for LTE; bit[11] is set for TDSCDMA; bit[12] is set for GSM in TG; bit[13] is set for WCDMA; bit[14] is set for GSM in WG." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
      BITFLD.LONG 0x00 5.--9. "  DAC2_CHANNEL_MASK , Set the bit high will enable the request to DAC2.bit[5] is set for LTE; bit[6] is set for TDSCDMA; bit[7] is set for GSM in TG; bit[8] is set for WCDMA; bit[9] is set for GSM in WG." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
      BITFLD.LONG 0x00 0.--4. "  DAC1_CHANNEL_MASK , Set the bit high will enable the request to DAC1.bit[0] is set for LTE; bit[1] is set for TDSCDMA; bit[2] is set for GSM in TG; bit[3] is set for WCDMA; bit[4] is set for GSM in WG." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
      TEXTLINE "                           "
  GROUP.LONG 0x000C++0x3 "0x02070000 + 0x000C"
    LINE.LONG 0x00 "MDAR_CFG3"
      BITFLD.LONG 0x00 28.--31. "  Reserved , Reserved" "Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved"
      BITFLD.LONG 0x00 16.--27. "  DACX_SBC_SET , This register must be keep to 0x800, any other value may lead fatal error." "none"
      BITFLD.LONG 0x00 13.--15. "  Reserved , Reserved" "Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved"
      BITFLD.LONG 0x00 0.--12. "  ADCX_SBC_SET , Keep these bits to 0, writing 1 to these bits may lead fatal error." "none"
      TEXTLINE "                           "
  GROUP.LONG 0x0010++0x3 "0x02070000 + 0x0010"
    LINE.LONG 0x00 "MDAR_DAC1_CTR1"
      BITFLD.LONG 0x00 16.--31. "  DAC1_WD_OVR     , DAC1 parameter control; Bit weight override write input Default 16’b0" "none"
      BITFLD.LONG 0x00 4.--7. "   DAC1_WADDR_OVR , DAC1 parameter control; Bit weight override address Default 0000" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
      BITFLD.LONG 0x00 3. "  Reserved , Reserved" "Reserved,Reserved"
      BITFLD.LONG 0x00 2. "  DAC1_WLE_OVR , DAC1 parameter control; Bit weight override load enable 0(def)      unable  1             enable" "0,1"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 1. "  DAC1_W_OVR_I_QN , DAC1 parameter control; Select which channel to override 0(def)      Channel Q 1            Channel I" "0,1"
      BITFLD.LONG 0x00 0. "  DAC1_W_OVR_EN  , DAC1 parameter control; Enable Bit weight register override  0(def)      unable  1            enable" "0,1"
  GROUP.LONG 0x0014++0x3 "0x02070000 + 0x0014"
    LINE.LONG 0x00 "MDAR_DAC1_CTR2"
      BITFLD.LONG 0x00 23. "  DAC1_AUTO_RST   , " "0,1"
      BITFLD.LONG 0x00 22. "  DAC1_SOFT_RST  , " "0,1"
      BITFLD.LONG 0x00 21. "  DAC1_OSBC   , This bit determinate the input data's format of the DAC1 weight process function. 1 means the 2’s complement code; 0 means offset binary code. This bit must set to 1." "0,1"
      BITFLD.LONG 0x00 20. "  DAC1_ISBC      , When the output data of the communication system's TX is format in 2’s complement code, this bit must set to1, otherwise this bit should be 0." "0,1"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 19. "  DAC1_OVR_EN_CAL , DAC1 parameter control;" "0,1"
      BITFLD.LONG 0x00 18. "  DAC1_EN_OOSCAL , DAC1 parameter control;" "0,1"
      BITFLD.LONG 0x00 17. "  DAC1_IQSWAP , DAC1 IQ switch" "0,1"
      BITFLD.LONG 0x00 16. "  DAC1_CAL_START , DAC1 self calibration start" "0,1"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 8.--15. "  DAC1_OFFSETI    , DAC1 parameter control;" "none"
      BITFLD.LONG 0x00 0.--7. "   DAC1_OFFSETQ   , DAC1 parameter control;" "none"
  GROUP.LONG 0x0018++0x3 "0x02070000 + 0x0018"
    LINE.LONG 0x00 "MDAR_DAC1_CTR3"
      BITFLD.LONG 0x00 28.--31. "  Reserved , Reserved" "Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved"
      BITFLD.LONG 0x00 16.--27. "  DAC1_Q_DC , DAC1  Q  DC bias;" "none"
      BITFLD.LONG 0x00 12.--15. "  Reserved , Reserved" "Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved"
      BITFLD.LONG 0x00 0.--11. "  DAC1_I_DC , DAC1  I DC bias;" "none"
      TEXTLINE "                           "
  GROUP.LONG 0x001C++0x3 "0x02070000 + 0x001C"
    LINE.LONG 0x00 "MDAR_DAC1_CTR4"
      BITFLD.LONG 0x00 28.--31. "  Reserved , Reserved" "Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved"
      BITFLD.LONG 0x00 16.--27. "  DAC1_I_CAL , DAC1 I input when 'ADA1_MODE_SEL = 1'b1'." "none"
      BITFLD.LONG 0x00 12.--15. "  Reserved , Reserved" "Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved"
      BITFLD.LONG 0x00 0.--11. "  DAC1_Q_CAL , DAC1 Q input when 'ADA1_MODE_SEL = 1'b1'." "none"
      TEXTLINE "                           "
  GROUP.LONG 0x0020++0x3 "0x02070000 + 0x0020"
    LINE.LONG 0x00 "MDAR_DAC1_STS0"
      BITFLD.LONG 0x00 16.--31. "  DAC1_WTI , DAC1 parameter control;" "none"
      BITFLD.LONG 0x00 0.--15. "  DAC1_WTQ , DAC1 parameter control;" "none"
  GROUP.LONG 0x0024++0x3 "0x02070000 + 0x0024"
    LINE.LONG 0x00 "MDAR_DAC1_STS1"
      BITFLD.LONG 0x00 17.--18. "  DAC1_DA_STATE , DAC1 parameter status" "0,1,2,3"
      BITFLD.LONG 0x00 16. "  DAC1_DONE , DAC1 parameter control, indicating DAC1 calibration done" "0,1"
      BITFLD.LONG 0x00 0.--15. "  DAC1_WQ_OVR , DAC1 parameter status" "none"
  GROUP.LONG 0x0028++0x3 "0x02070000 + 0x0028"
    LINE.LONG 0x00 "MDAR_CAL1_CTR0"
      BITFLD.LONG 0x00 16.--23. "  ADC1_CLK_CAL_DLY , In ADA1 loop calibration, ADC1 CLK and DAC1 CLK are both 13MHz, but ADC1 CLK should have some delay time with DAC1 CLK.. ADC1_CLK_CAL_DLY[6:0]: the delay time selection. 1 unit is 0.1ns delay. ADC1_CLK_CAL_DLY[7]: invert DAC1_CLK input." "none"
      BITFLD.LONG 0x00 8.--15. "                      ADA1_CAL_WAIT , After ADA1_CAL_START, need wait (ADAC_CAL_WAIT + 1) cycle of 13MHz, then start  the calibration calculation start." "none"
      BITFLD.LONG 0x00 7. "          Reserved    , Reserved" "Reserved,Reserved"
      BITFLD.LONG 0x00 6. "           CLK_ADA1_CAL_EN , ADA1 calibration clock enable 0: disable; 1: enable. Make sure to disable ADA1 calibration clock before switch between normal mode and calibration mode." "disable;,enable. Make sure to disable ADA"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 5. "  DAC1_PD_CAL      , DAC1 power down control when 'ADA1_MODE_SEL = 1'b1'. 0: Force enable DAC1; 1: Force power down DAC1" "Force enable DAC,Force power down DAC"
      BITFLD.LONG 0x00 4. "  Reserved      , Reserved" "Reserved,Reserved"
      BITFLD.LONG 0x00 3. "  ADC1_EN_CAL , ADC1 enable control when 'ADA1_MODE_SEL = 1'b1'. 0: Force disable ADC1; 1: Force enable ADC1" "Force disable ADC,Force enable ADC"
      BITFLD.LONG 0x00 2. "  Reserved        , Reserved" "Reserved,Reserved"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 1. "  ADC1_CAL         , ADC1 dc offset calibration 0: normal mode 1: calibration mode" "normal mode,calibration mode"
      BITFLD.LONG 0x00 0. "      ADA1_MODE_SEL , ADA1 work mode selection 0: normal; 1: calibration mode" "normal;,calibration mode"
  GROUP.LONG 0x002C++0x3 "0x02070000 + 0x002C"
    LINE.LONG 0x00 "MDAR_CAL1_CTR1"
      BITFLD.LONG 0x00 29.--31. "  Reserved , Reserved" "Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved"
      BITFLD.LONG 0x00 16.--28. "  ADC1_Q_DC , ADC1 Q DC offset" "none"
      BITFLD.LONG 0x00 13.--15. "  Reserved , Reserved" "Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved"
      BITFLD.LONG 0x00 0.--12. "  ADC1_I_DC , ADC1 I DC offset" "none"
      TEXTLINE "                           "
  GROUP.LONG 0x0030++0x3 "0x02070000 + 0x0030"
    LINE.LONG 0x00 "MDAR_CAL1_CTR3"
      BITFLD.LONG 0x00 0. "  ADA1_CAL_START , Write 1 to start ADA1 calibration. It is self-cleared" "0,1"
  GROUP.LONG 0x0034++0x3 "0x02070000 + 0x0034"
    LINE.LONG 0x00 "MDAR_CAL1_STS0"
      BITFLD.LONG 0x00 31. "  ADA1_CAL_DONE , ADA1 calibration done. Active high" "0,1"
      BITFLD.LONG 0x00 0.--19. "  ADC1_CAL_I_SUM , Sum of 128 ADC1_I data" "none"
  GROUP.LONG 0x0038++0x3 "0x02070000 + 0x0038"
    LINE.LONG 0x00 "MDAR_CAL1_STS1"
      BITFLD.LONG 0x00 0.--19. "  ADC1_CAL_Q_SUM , Sum of 128 ADC1_Q data" "none"
  GROUP.LONG 0x003C++0x3 "0x02070000 + 0x003C"
    LINE.LONG 0x00 "MDAR_DAC1_CTR00"
      BITFLD.LONG 0x00 27.--31. "  Reserved       , Reserved" "Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved"
      BITFLD.LONG 0x00 26. "  DAC1_OUT_SEL_2 , DAC1 parameter for channel2. Reserved" "0,1"
      BITFLD.LONG 0x00 22.--25. "  DAC1_RSV_2 , DAC1 parameter for channel2. Reserved bits" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
      BITFLD.LONG 0x00 19.--21. "  DAC1_PCTRL_2 , DAC1 parameter for channel2. [2],Select the edge of the digital clock 0(def)    positive edge of clock sample 1            negative edge of clock sample                                                                   [1:0],Choose DAC output voltage level  00   500mV(SE) 01    625mV(SE) 10    360mV(SE) 11    420mV(SE)" "0,1,2,3,4,5,6,7"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 18. "  DAC1_CLK_SEL_2 , DAC1 parameter for channel2. Select the edge of the analog clock 0(def)    positive edge of clock sample 1          negative edge of clock sample" "0,1"
      BITFLD.LONG 0x00 17. "         DAC1_OUT_SEL_1 , DAC1 parameter for channel1. Reserved" "0,1"
      BITFLD.LONG 0x00 13.--16. "  DAC1_RSV_1 , DAC1 parameter for channel1. Reserved bits" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
      BITFLD.LONG 0x00 10.--12. "  DAC1_PCTRL_1 , DAC1 parameter for channel1. [2],Select the edge of the digital clock 0(def)    positive edge of clock sample 1            negative edge of clock sample                                                                   [1:0],Choose DAC output voltage level  00   500mV(SE) 01    625mV(SE) 10    360mV(SE) 11    420mV(SE)" "0,1,2,3,4,5,6,7"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 9. "  DAC1_CLK_SEL_1 , DAC1 parameter for channel1. Select the edge of the analog clock 0(def)    positive edge of clock sample 1          negative edge of clock sample" "0,1"
      BITFLD.LONG 0x00 8. "         DAC1_OUT_SEL_0 , DAC1 parameter for channel0. Reserved" "0,1"
      BITFLD.LONG 0x00 4.--7. "  DAC1_RSV_0 , DAC1 parameter for channel0. Reserved bits" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
      BITFLD.LONG 0x00 1.--3. "  DAC1_PCTRL_0 , DAC1 parameter for channel0. [2],Select the edge of the digital clock 0(def)    positive edge of clock sample 1            negative edge of clock sample                                                                   [1:0],Choose DAC output voltage level  00   500mV(SE) 01    625mV(SE) 10    360mV(SE) 11    420mV(SE)" "0,1,2,3,4,5,6,7"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 0. "  DAC1_CLK_SEL_0 , DAC1 parameter for channel0. Select the edge of the analog clock 0(def)    positive edge of clock sample 1          negative edge of clock sample" "0,1"
  GROUP.LONG 0x0040++0x3 "0x02070000 + 0x0040"
    LINE.LONG 0x00 "MDAR_DAC1_CTR10"
      BITFLD.LONG 0x00 27.--31. "  Reserved       , Reserved" "Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved"
      BITFLD.LONG 0x00 26. "  DAC1_OUT_SEL_5 , DAC1 parameter for channel5. Reserved" "0,1"
      BITFLD.LONG 0x00 22.--25. "  DAC1_RSV_5 , DAC1 parameter for channel5. Reserved bits" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
      BITFLD.LONG 0x00 19.--21. "  DAC1_PCTRL_5 , DAC1 parameter for channel5. [2],Select the edge of the digital clock 0(def)    positive edge of clock sample 1            negative edge of clock sample                                                                   [1:0],Choose DAC output voltage level  00   500mV(SE) 01    625mV(SE) 10    360mV(SE) 11    420mV(SE)" "0,1,2,3,4,5,6,7"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 18. "  DAC1_CLK_SEL_5 , DAC1 parameter for channel5. Select the edge of the analog clock 0(def)    positive edge of clock sample 1          negative edge of clock sample" "0,1"
      BITFLD.LONG 0x00 17. "         DAC1_OUT_SEL_4 , DAC1 parameter for channel4. Reserved" "0,1"
      BITFLD.LONG 0x00 13.--16. "  DAC1_RSV_4 , DAC1 parameter for channel4. Reserved bits" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
      BITFLD.LONG 0x00 10.--12. "  DAC1_PCTRL_4 , DAC1 parameter for channel4. [2],Select the edge of the digital clock 0(def)    positive edge of clock sample 1            negative edge of clock sample                                                                   [1:0],Choose DAC output voltage level  00   500mV(SE) 01    625mV(SE) 10    360mV(SE) 11    420mV(SE)" "0,1,2,3,4,5,6,7"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 9. "  DAC1_CLK_SEL_4 , DAC1 parameter for channel4. Select the edge of the analog clock 0(def)    positive edge of clock sample 1          negative edge of clock sample" "0,1"
      BITFLD.LONG 0x00 8. "         DAC1_OUT_SEL_3 , DAC1 parameter for channel3. Reserved" "0,1"
      BITFLD.LONG 0x00 4.--7. "  DAC1_RSV_3 , DAC1 parameter for channel3. Reserved bits" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
      BITFLD.LONG 0x00 1.--3. "  DAC1_PCTRL_3 , DAC1 parameter for channel3. [2],Select the edge of the digital clock 0(def)    positive edge of clock sample 1            negative edge of clock sample                                                                   [1:0],Choose DAC output voltage level  00   500mV(SE) 01    625mV(SE) 10    360mV(SE) 11    420mV(SE)" "0,1,2,3,4,5,6,7"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 0. "  DAC1_CLK_SEL_3 , DAC1 parameter for channel3. Select the edge of the analog clock 0(def)    positive edge of clock sample 1          negative edge of clock sample" "0,1"
  GROUP.LONG 0x0044++0x3 "0x02070000 + 0x0044"
    LINE.LONG 0x00 "MDAR_ADC1_CTR0"
      BITFLD.LONG 0x00 31. "  ADC1_SOFT_RST     , " "0,1"
      BITFLD.LONG 0x00 25.--30. "  ADC1_DLL_OUT , ADC1 DLL data from analog part." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
      BITFLD.LONG 0x00 11.--24. "  ADC1_CALRDOUT , ADC1 calibration data from analog part." "none"
      BITFLD.LONG 0x00 10. "   ADC1_DLL_SOFT_RST , " "0,1"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 9. "  ADC1_CAL_SOFT_RST , " "0,1"
      BITFLD.LONG 0x00 8. "  ADC1_CALRD   , ADC1 Cap calibration read enable, high effective, default 0" "0,1"
      BITFLD.LONG 0x00 7. "   ADC1_CALEN    , ADC1 Cap calibration Enable, high effective, default 0;" "0,1"
      BITFLD.LONG 0x00 1.--6. "  ADC1_CALADDR      , ADC1 Cap calibration address, Default:000000" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 0. "  ADC1_DEBUG_EN     , ADC1 debug mode enable, high effective, default 0" "0,1"
  GROUP.LONG 0x0048++0x3 "0x02070000 + 0x0048"
    LINE.LONG 0x00 "MDAR_ADC1_CTR00"
      BITFLD.LONG 0x00 16.--31. "  ADC1_RSV_1 , Reserved" "none"
      BITFLD.LONG 0x00 0.--15. "  ADC1_RSV_0 , Reserved" "none"
  GROUP.LONG 0x004C++0x3 "0x02070000 + 0x004C"
    LINE.LONG 0x00 "MDAR_ADC1_CTR01"
      BITFLD.LONG 0x00 31. "  Reserved       , Reserved" "Reserved,Reserved"
      BITFLD.LONG 0x00 30. "  ADC1_DIG_CLK_SEL_0 , ADC1 parameter of channel0.  digital clk Sel, default 0" "0,1"
      BITFLD.LONG 0x00 29. "   ADC1_VCM_SEL_0    , ADC1 parameter of channel0.  VCM Sel Signal, default 1 (low VCM voltage)" "0,1"
      BITFLD.LONG 0x00 27.--28. "                            ADC1_DELAY_CAP_0   , ADC1 parameter of channel0. delay cap sel, 0:high speed, default 10;" "high speed- default,1,2,3"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 25.--26. "  ADC1_BIT_SEL_0 , ADC1 parameter of channel0.  bit sel, default 0; 00:14 bits; 01 :13bits, 10:12 bits, 11:11bits" "1,1,2,3"
      BITFLD.LONG 0x00 23.--24. "         ADC1_VREF_SEL_0    , ADC1 parameter of channel0. Vref sel; default 2'h2;" "0,1,2,3"
      BITFLD.LONG 0x00 21.--22. "   ADC1_VREF_BOOST_0 , ADC1 parameter of channel0. vref boost speed, default 11; 00:min current, 11:max current" "min current-,1,2,3"
      BITFLD.LONG 0x00 19.--20. "                 ADC1_QUANT_BOOST_0 , ADC1 parameter of channel0. quant boost speed, default 11;  00: min current; 11:max current" "min current;,1,2,3"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 18. "  ADC1_DLLRD_0   , ADC1 parameter of channel0. DLL read enable, high effective, default 0" "0,1"
      BITFLD.LONG 0x00 17. "         ADC1_DLLWR_0       , ADC1 parameter of channel0. DLL write enable, high effective, default 0" "0,1"
      BITFLD.LONG 0x00 16. "   ADC1_DLLEN_0      , ADC1 parameter of channel0. DLL enable, high effective, default 1" "0,1"
      BITFLD.LONG 0x00 15. "                            ADC1_CSBC          , 1:the mrda ADC1 calibration data formate is the 2's complement code format; 0:the mrda ADC1 calibration data formate is the offset binary code. Should be 1 in the present system." "the mrda ADC,the mrda ADC"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 14. "  ADC1_IQSWAP    , ADC1 IQ switch, active high" "0,1"
      BITFLD.LONG 0x00 8.--13. "         ADC1_DLLOOF_0      , ADC1 parameter of channel0. DLL offset input, default 0" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
      BITFLD.LONG 0x00 7. "  ADC1_OSBC         , 1:the mrda output data of ADC1 is in the 2's complement code format; 0:the mrda output data of ADC1 is in the offset binary code. Should be 1 in the present system." "the mrda output data of ADC,the mrda output data of ADC"
      BITFLD.LONG 0x00 6. "  ADC1_ISBC          , 1:the superadc1 output data is in the 2's complement code format; 0:the superadc1 output data is in the offset binary code. Should be 0 in the present system." "the superadc,the superadc"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 0.--5. "  ADC1_DLLIN_0   , ADC1 parameter of channel0. DLL INPUT, default 0" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
  GROUP.LONG 0x0050++0x3 "0x02070000 + 0x0050"
    LINE.LONG 0x00 "MDAR_ADC1_CTR02"
      BITFLD.LONG 0x00 31. "  Reserved       , Reserved" "Reserved,Reserved"
      BITFLD.LONG 0x00 30. "  ADC1_DIG_CLK_SEL_1 , ADC1 parameter of channel1.  digital clk Sel, default 0" "0,1"
      BITFLD.LONG 0x00 29. "   ADC1_VCM_SEL_1    , ADC1 parameter of channel1.  VCM Sel Signal, default 1 (low VCM voltage)" "0,1"
      BITFLD.LONG 0x00 27.--28. "             ADC1_DELAY_CAP_1   , ADC1 parameter of channel1. delay cap sel, 0:high speed, default 10;" "high speed- default,1,2,3"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 25.--26. "  ADC1_BIT_SEL_1 , ADC1 parameter of channel1.  bit sel, default 0; 00:14 bits; 01 :13bits, 10:12 bits, 11:11bits" "1,1,2,3"
      BITFLD.LONG 0x00 23.--24. "         ADC1_VREF_SEL_1    , ADC1 parameter of channel1. Vref sel; default 2'h2;" "0,1,2,3"
      BITFLD.LONG 0x00 21.--22. "   ADC1_VREF_BOOST_1 , ADC1 parameter of channel1. vref boost speed, default 11; 00:min current, 11:max current" "min current-,1,2,3"
      BITFLD.LONG 0x00 19.--20. "  ADC1_QUANT_BOOST_1 , ADC1 parameter of channel1. quant boost speed, default 11;  00: min current; 11:max current" "min current;,1,2,3"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 18. "  ADC1_DLLRD_1   , ADC1 parameter of channel1. DLL read enable, high effective, default 0" "0,1"
      BITFLD.LONG 0x00 17. "         ADC1_DLLWR_1       , ADC1 parameter of channel1. DLL write enable, high effective, default 0" "0,1"
      BITFLD.LONG 0x00 16. "   ADC1_DLLEN_1      , ADC1 parameter of channel1. DLL enable, high effective, default 1" "0,1"
      BITFLD.LONG 0x00 15. "             Reserved           , Reserved" "Reserved,Reserved"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 14. "  Reserved       , Reserved" "Reserved,Reserved"
      BITFLD.LONG 0x00 8.--13. "  ADC1_DLLOOF_1      , ADC1 parameter of channel1. DLL offset input, default 0" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
      BITFLD.LONG 0x00 7. "  Reserved          , Reserved" "Reserved,Reserved"
      BITFLD.LONG 0x00 6. "      Reserved           , Reserved" "Reserved,Reserved"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 0.--5. "  ADC1_DLLIN_1   , ADC1 parameter of channel1. DLL INPUT, default 0" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
  GROUP.LONG 0x0054++0x3 "0x02070000 + 0x0054"
    LINE.LONG 0x00 "MDAR_ADC1_CTR10"
      BITFLD.LONG 0x00 16.--31. "  ADC1_RSV_3 , Reserved" "none"
      BITFLD.LONG 0x00 0.--15. "  ADC1_RSV_2 , Reserved" "none"
  GROUP.LONG 0x0058++0x3 "0x02070000 + 0x0058"
    LINE.LONG 0x00 "MDAR_ADC1_CTR11"
      BITFLD.LONG 0x00 31. "  Reserved       , Reserved" "Reserved,Reserved"
      BITFLD.LONG 0x00 30. "  ADC1_DIG_CLK_SEL_2 , ADC1 parameter of channel2.  digital clk Sel, default 0" "0,1"
      BITFLD.LONG 0x00 29. "   ADC1_VCM_SEL_2    , ADC1 parameter of channel2.  VCM Sel Signal, default 1 (low VCM voltage)" "0,1"
      BITFLD.LONG 0x00 27.--28. "             ADC1_DELAY_CAP_2   , ADC1 parameter of channel2. delay cap sel, 0:high speed, default 10;" "high speed- default,1,2,3"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 25.--26. "  ADC1_BIT_SEL_2 , ADC1 parameter of channel2.  bit sel, default 0; 00:14 bits; 01 :13bits, 10:12 bits, 11:11bits" "1,1,2,3"
      BITFLD.LONG 0x00 23.--24. "         ADC1_VREF_SEL_2    , ADC1 parameter of channel2. Vref sel; default 2;" "0,1,2,3"
      BITFLD.LONG 0x00 21.--22. "   ADC1_VREF_BOOST_2 , ADC1 parameter of channel2. vref boost speed, default 11; 00:min current, 11:max current" "min current-,1,2,3"
      BITFLD.LONG 0x00 19.--20. "  ADC1_QUANT_BOOST_2 , ADC1 parameter of channel2. quant boost speed, default 11;  00: min current; 11:max current" "min current;,1,2,3"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 18. "  ADC1_DLLRD_2   , ADC1 parameter of channel2. DLL read enable, high effective, default 0" "0,1"
      BITFLD.LONG 0x00 17. "         ADC1_DLLWR_2       , ADC1 parameter of channel2. DLL write enable, high effective, default 0" "0,1"
      BITFLD.LONG 0x00 16. "   ADC1_DLLEN_2      , ADC1 parameter of channel2. DLL enable, high effective, default 1" "0,1"
      BITFLD.LONG 0x00 15. "             Reserved           , Reserved" "Reserved,Reserved"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 14. "  Reserved       , Reserved" "Reserved,Reserved"
      BITFLD.LONG 0x00 8.--13. "  ADC1_DLLOOF_2      , ADC1 parameter of channel2. DLL offset input, default 0" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
      BITFLD.LONG 0x00 7. "  Reserved          , Reserved" "Reserved,Reserved"
      BITFLD.LONG 0x00 6. "      Reserved           , Reserved" "Reserved,Reserved"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 0.--5. "  ADC1_DLLIN_2   , ADC1 parameter of channel2. DLL INPUT, default 0" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
  GROUP.LONG 0x005C++0x3 "0x02070000 + 0x005C"
    LINE.LONG 0x00 "MDAR_ADC1_CTR12"
      BITFLD.LONG 0x00 31. "  Reserved       , Reserved" "Reserved,Reserved"
      BITFLD.LONG 0x00 30. "  ADC1_DIG_CLK_SEL_3 , ADC1 parameter of channel3.  digital clk Sel, default 0" "0,1"
      BITFLD.LONG 0x00 29. "   ADC1_VCM_SEL_3    , ADC1 parameter of channel3.  VCM Sel Signal, default 1 (low VCM voltage)" "0,1"
      BITFLD.LONG 0x00 27.--28. "             ADC1_DELAY_CAP_3   , ADC1 parameter of channel3. delay cap sel, 0:high speed, default 10;" "high speed- default,1,2,3"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 25.--26. "  ADC1_BIT_SEL_3 , ADC1 parameter of channel3.  bit sel, default 0; 00:14 bits; 01 :13bits, 10:12 bits, 11:11bits" "1,1,2,3"
      BITFLD.LONG 0x00 23.--24. "         ADC1_VREF_SEL_3    , ADC1 parameter of channel3. Vref sel; default 2;" "0,1,2,3"
      BITFLD.LONG 0x00 21.--22. "   ADC1_VREF_BOOST_3 , ADC1 parameter of channel3. vref boost speed, default 11; 00:min current, 11:max current" "min current-,1,2,3"
      BITFLD.LONG 0x00 19.--20. "  ADC1_QUANT_BOOST_3 , ADC1 parameter of channel3. quant boost speed, default 11;  00: min current; 11:max current" "min current;,1,2,3"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 18. "  ADC1_DLLRD_3   , ADC1 parameter of channel3. DLL read enable, high effective, default 0" "0,1"
      BITFLD.LONG 0x00 17. "         ADC1_DLLWR_3       , ADC1 parameter of channel3. DLL write enable, high effective, default 0" "0,1"
      BITFLD.LONG 0x00 16. "   ADC1_DLLEN_3      , ADC1 parameter of channel3. DLL enable, high effective, default 1" "0,1"
      BITFLD.LONG 0x00 15. "             Reserved           , Reserved" "Reserved,Reserved"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 14. "  Reserved       , Reserved" "Reserved,Reserved"
      BITFLD.LONG 0x00 8.--13. "  ADC1_DLLOOF_3      , ADC1 parameter of channel3. DLL offset input, default 0" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
      BITFLD.LONG 0x00 7. "  Reserved          , Reserved" "Reserved,Reserved"
      BITFLD.LONG 0x00 6. "      Reserved           , Reserved" "Reserved,Reserved"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 0.--5. "  ADC1_DLLIN_3   , ADC1 parameter of channel3. DLL INPUT, default 0" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
  GROUP.LONG 0x0060++0x3 "0x02070000 + 0x0060"
    LINE.LONG 0x00 "MDAR_ADC1_CTR20"
      BITFLD.LONG 0x00 16.--31. "  ADC1_RSV_5 , Reserved" "none"
      BITFLD.LONG 0x00 0.--15. "  ADC1_RSV_4 , Reserved" "none"
  GROUP.LONG 0x0064++0x3 "0x02070000 + 0x0064"
    LINE.LONG 0x00 "MDAR_ADC1_CTR21"
      BITFLD.LONG 0x00 31. "  Reserved       , Reserved" "Reserved,Reserved"
      BITFLD.LONG 0x00 30. "  ADC1_DIG_CLK_SEL_4 , ADC1 parameter of channel4.  digital clk Sel, default 0" "0,1"
      BITFLD.LONG 0x00 29. "   ADC1_VCM_SEL_4    , ADC1 parameter of channel4.  VCM Sel Signal, default 0 (low VCM voltage)" "0,1"
      BITFLD.LONG 0x00 27.--28. "             ADC1_DELAY_CAP_4   , ADC1 parameter of channel4. delay cap sel, 0:high speed, default 10;" "high speed- default,1,2,3"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 25.--26. "  ADC1_BIT_SEL_4 , ADC1 parameter of channel4.  bit sel, default 0; 00:14 bits; 01 :13bits, 10:12 bits, 11:11bits" "1,1,2,3"
      BITFLD.LONG 0x00 23.--24. "         ADC1_VREF_SEL_4    , ADC1 parameter of channel4. Vref sel; default 2;" "0,1,2,3"
      BITFLD.LONG 0x00 21.--22. "   ADC1_VREF_BOOST_4 , ADC1 parameter of channel4. vref boost speed, default 11; 00:min current, 11:max current" "min current-,1,2,3"
      BITFLD.LONG 0x00 19.--20. "  ADC1_QUANT_BOOST_4 , ADC1 parameter of channel4. quant boost speed, default 11;  00: min current; 11:max current" "min current;,1,2,3"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 18. "  ADC1_DLLRD_4   , ADC1 parameter of channel4. DLL read enable, high effective, default 0" "0,1"
      BITFLD.LONG 0x00 17. "         ADC1_DLLWR_4       , ADC1 parameter of channel4. DLL write enable, high effective, default 0" "0,1"
      BITFLD.LONG 0x00 16. "   ADC1_DLLEN_4      , ADC1 parameter of channel4. DLL enable, high effective, default 1" "0,1"
      BITFLD.LONG 0x00 15. "             Reserved           , Reserved" "Reserved,Reserved"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 14. "  Reserved       , Reserved" "Reserved,Reserved"
      BITFLD.LONG 0x00 8.--13. "  ADC1_DLLOOF_4      , ADC1 parameter of channel4. DLL offset input, default 0" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
      BITFLD.LONG 0x00 7. "  Reserved          , Reserved" "Reserved,Reserved"
      BITFLD.LONG 0x00 6. "      Reserved           , Reserved" "Reserved,Reserved"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 0.--5. "  ADC1_DLLIN_4   , ADC1 parameter of channel4. DLL INPUT, default 0" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
  GROUP.LONG 0x0068++0x3 "0x02070000 + 0x0068"
    LINE.LONG 0x00 "MDAR_ADC1_CTR22"
      BITFLD.LONG 0x00 31. "  Reserved       , Reserved" "Reserved,Reserved"
      BITFLD.LONG 0x00 30. "  ADC1_DIG_CLK_SEL_5 , ADC1 parameter of channel5.  digital clk Sel, default 0" "0,1"
      BITFLD.LONG 0x00 29. "   ADC1_VCM_SEL_5    , ADC1 parameter of channel5.  VCM Sel Signal, default 0 (low VCM voltage)" "0,1"
      BITFLD.LONG 0x00 27.--28. "             ADC1_DELAY_CAP_5   , ADC1 parameter of channel5. delay cap sel, 0:high speed, default 10;" "high speed- default,1,2,3"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 25.--26. "  ADC1_BIT_SEL_5 , ADC1 parameter of channel5.  bit sel, default 0; 00:14 bits; 01 :13bits, 10:12 bits, 11:11bits" "1,1,2,3"
      BITFLD.LONG 0x00 23.--24. "         ADC1_VREF_SEL_5    , ADC1 parameter of channel5. Vref sel; default 2;" "0,1,2,3"
      BITFLD.LONG 0x00 21.--22. "   ADC1_VREF_BOOST_5 , ADC1 parameter of channel5. vref boost speed, default 11; 00:min current, 11:max current" "min current-,1,2,3"
      BITFLD.LONG 0x00 19.--20. "  ADC1_QUANT_BOOST_5 , ADC1 parameter of channel5. quant boost speed, default 11;  00: min current; 11:max current" "min current;,1,2,3"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 18. "  ADC1_DLLRD_5   , ADC1 parameter of channel5. DLL read enable, high effective, default 0" "0,1"
      BITFLD.LONG 0x00 17. "         ADC1_DLLWR_5       , ADC1 parameter of channel5. DLL write enable, high effective, default 0" "0,1"
      BITFLD.LONG 0x00 16. "   ADC1_DLLEN_5      , ADC1 parameter of channel5. DLL enable, high effective, default 1" "0,1"
      BITFLD.LONG 0x00 15. "             Reserved           , Reserved" "Reserved,Reserved"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 14. "  Reserved       , Reserved" "Reserved,Reserved"
      BITFLD.LONG 0x00 8.--13. "  ADC1_DLLOOF_5      , ADC1 parameter of channel5. DLL offset input, default 0" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
      BITFLD.LONG 0x00 7. "  Reserved          , Reserved" "Reserved,Reserved"
      BITFLD.LONG 0x00 6. "      Reserved           , Reserved" "Reserved,Reserved"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 0.--5. "  ADC1_DLLIN_5   , ADC1 parameter of channel5. DLL INPUT, default 0" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
  GROUP.LONG 0x0070++0x3 "0x02070000 + 0x0070"
    LINE.LONG 0x00 "MDAR_DAC2_CTR1"
      BITFLD.LONG 0x00 16.--31. "  DAC2_WD_OVR     , DAC2 parameter control; Bit weight override write input Default 16’b0" "none"
      BITFLD.LONG 0x00 4.--7. "   DAC2_WADDR_OVR , DAC2 parameter control; Bit weight override address Default 0000" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
      BITFLD.LONG 0x00 3. "  Reserved , Reserved" "Reserved,Reserved"
      BITFLD.LONG 0x00 2. "  DAC2_WLE_OVR , DAC2 parameter control; Bit weight override load enable 0(def)      unable  1             enable" "0,1"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 1. "  DAC2_W_OVR_I_QN , DAC2 parameter control; Select which channel to override 0(def)      Channel Q 1            Channel I" "0,1"
      BITFLD.LONG 0x00 0. "  DAC2_W_OVR_EN  , DAC2 parameter control; Enable Bit weight register override  0(def)      unable  1            enable" "0,1"
  GROUP.LONG 0x0074++0x3 "0x02070000 + 0x0074"
    LINE.LONG 0x00 "MDAR_DAC2_CTR2"
      BITFLD.LONG 0x00 23. "  DAC2_AUTO_RST   , " "0,1"
      BITFLD.LONG 0x00 22. "  DAC2_SOFT_RST  , " "0,1"
      BITFLD.LONG 0x00 21. "  DAC2_OSBC   , This bit determinate the input data's format of the DAC2 weight process function. 1 means the 2’s complement code; 0 means offset binary code. This bit must set to 1." "0,1"
      BITFLD.LONG 0x00 20. "  DAC2_ISBC      , When the output data of the communication system's TX is format in 2’s complement code, this bit must set to1, otherwise this bit should be 0." "0,1"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 19. "  DAC2_OVR_EN_CAL , DAC2 parameter control;" "0,1"
      BITFLD.LONG 0x00 18. "  DAC2_EN_OOSCAL , DAC2 parameter control;" "0,1"
      BITFLD.LONG 0x00 17. "  DAC2_IQSWAP , DAC2 IQ switch" "0,1"
      BITFLD.LONG 0x00 16. "  DAC2_CAL_START , DAC2 self calibration start" "0,1"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 8.--15. "  DAC2_OFFSETI    , DAC2 parameter control;" "none"
      BITFLD.LONG 0x00 0.--7. "   DAC2_OFFSETQ   , DAC2 parameter control;" "none"
  GROUP.LONG 0x0078++0x3 "0x02070000 + 0x0078"
    LINE.LONG 0x00 "MDAR_DAC2_CTR3"
      BITFLD.LONG 0x00 28.--31. "  Reserved , Reserved" "Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved"
      BITFLD.LONG 0x00 16.--27. "  DAC2_Q_DC , DAC2  Q  DC bias;" "none"
      BITFLD.LONG 0x00 12.--15. "  Reserved , Reserved" "Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved"
      BITFLD.LONG 0x00 0.--11. "  DAC2_I_DC , DAC2  I DC bias;" "none"
      TEXTLINE "                           "
  GROUP.LONG 0x007C++0x3 "0x02070000 + 0x007C"
    LINE.LONG 0x00 "MDAR_DAC2_CTR4"
      BITFLD.LONG 0x00 28.--31. "  Reserved , Reserved" "Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved"
      BITFLD.LONG 0x00 16.--27. "  DAC2_I_CAL , DAC2 I input when 'ADA2_MODE_SEL = 1'b1'." "none"
      BITFLD.LONG 0x00 12.--15. "  Reserved , Reserved" "Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved"
      BITFLD.LONG 0x00 0.--11. "  DAC2_Q_CAL , DAC2 Q input when 'ADA2_MODE_SEL = 1'b1'." "none"
      TEXTLINE "                           "
  GROUP.LONG 0x0080++0x3 "0x02070000 + 0x0080"
    LINE.LONG 0x00 "MDAR_DAC2_STS0"
      BITFLD.LONG 0x00 16.--31. "  DAC2_WTI , DAC2 parameter control;" "none"
      BITFLD.LONG 0x00 0.--15. "  DAC2_WTQ , DAC2 parameter control;" "none"
  GROUP.LONG 0x0084++0x3 "0x02070000 + 0x0084"
    LINE.LONG 0x00 "MDAR_DAC2_STS1"
      BITFLD.LONG 0x00 17.--18. "  DAC2_DA_STATE , DAC2 parameter status" "0,1,2,3"
      BITFLD.LONG 0x00 16. "  DAC2_DONE , DAC2 parameter control, indicating DAC2 calibration done" "0,1"
      BITFLD.LONG 0x00 0.--15. "  DAC2_WQ_OVR , DAC2 parameter status" "none"
  GROUP.LONG 0x0088++0x3 "0x02070000 + 0x0088"
    LINE.LONG 0x00 "MDAR_CAL2_CTR0"
      BITFLD.LONG 0x00 16.--23. "  ADC2_CLK_CAL_DLY , In ADA2 loop calibration, ADC2 CLK and DAC2 CLK are both 13MHz, but ADC2 CLK should have some delay time with DAC2 CLK.. ADC2_CLK_CAL_DLY[6:0]: the delay time selection. 1 unit is 0.1ns delay. ADC2_CLK_CAL_DLY[7]: invert DAC2_CLK input." "none"
      BITFLD.LONG 0x00 8.--15. "                      ADA2_CAL_WAIT , After ADA2_CAL_START, need wait (ADAC_CAL_WAIT + 1) cycle of 13MHz, then start  the calibration calculation start." "none"
      BITFLD.LONG 0x00 7. "          Reserved    , Reserved" "Reserved,Reserved"
      BITFLD.LONG 0x00 6. "           CLK_ADA2_CAL_EN , ADA2 calibration clock enable 0: disable; 1: enable. Make sure to disable ADA2 calibration clock before switch between normal mode and calibration mode." "disable;,enable. Make sure to disable ADA"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 5. "  DAC2_PD_CAL      , DAC2 power down control when 'ADA2_MODE_SEL = 1'b1'. 0: Force enable DAC2; 1: Force power down DAC2" "Force enable DAC,Force power down DAC"
      BITFLD.LONG 0x00 4. "  Reserved      , Reserved" "Reserved,Reserved"
      BITFLD.LONG 0x00 3. "  ADC2_EN_CAL , ADC2 enable control when 'ADA2_MODE_SEL = 1'b1'. 0: Force disable ADC2; 1: Force enable ADC2" "Force disable ADC,Force enable ADC"
      BITFLD.LONG 0x00 2. "  Reserved        , Reserved" "Reserved,Reserved"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 1. "  ADC2_CAL         , ADC2 dc offset calibration 0: normal mode 1: calibration mode" "normal mode,calibration mode"
      BITFLD.LONG 0x00 0. "      ADA2_MODE_SEL , ADA2 work mode selection 0: normal; 1: calibration mode" "normal;,calibration mode"
  GROUP.LONG 0x008C++0x3 "0x02070000 + 0x008C"
    LINE.LONG 0x00 "MDAR_CAL2_CTR1"
      BITFLD.LONG 0x00 29.--31. "  Reserved , Reserved" "Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved"
      BITFLD.LONG 0x00 16.--28. "  ADC2_Q_DC , ADC2 Q DC offset" "none"
      BITFLD.LONG 0x00 13.--15. "  Reserved , Reserved" "Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved"
      BITFLD.LONG 0x00 0.--12. "  ADC2_I_DC , ADC2 I DC offset" "none"
      TEXTLINE "                           "
  GROUP.LONG 0x0090++0x3 "0x02070000 + 0x0090"
    LINE.LONG 0x00 "MDAR_CAL2_CTR3"
      BITFLD.LONG 0x00 0. "  ADA2_CAL_START , Write 1 to start ADA2 calibration. It is self-cleared" "0,1"
  GROUP.LONG 0x0094++0x3 "0x02070000 + 0x0094"
    LINE.LONG 0x00 "MDAR_CAL2_STS0"
      BITFLD.LONG 0x00 31. "  ADA2_CAL_DONE , ADA2 calibration done. Active high" "0,1"
      BITFLD.LONG 0x00 0.--19. "  ADC2_CAL_I_SUM , Sum of 128 ADC2_I data" "none"
  GROUP.LONG 0x0098++0x3 "0x02070000 + 0x0098"
    LINE.LONG 0x00 "MDAR_CAL2_STS1"
      BITFLD.LONG 0x00 0.--19. "  ADC2_CAL_Q_SUM , Sum of 128 ADC2_Q data" "none"
  GROUP.LONG 0x009C++0x3 "0x02070000 + 0x009C"
    LINE.LONG 0x00 "MDAR_DAC2_CTR00"
      BITFLD.LONG 0x00 27.--31. "  Reserved       , Reserved" "Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved"
      BITFLD.LONG 0x00 26. "  DAC2_OUT_SEL_2 , DAC2 parameter for channel2. Reserved" "0,1"
      BITFLD.LONG 0x00 22.--25. "  DAC2_RSV_2 , DAC2 parameter for channel2. Reserved bits" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
      BITFLD.LONG 0x00 19.--21. "  DAC2_PCTRL_2 , DAC2 parameter for channel2. [2],Select the edge of the digital clock 0(def)    positive edge of clock sample 1            negative edge of clock sample                                                                   [1:0],Choose DAC output voltage level  00   500mV(SE) 01    625mV(SE) 10    360mV(SE) 11    420mV(SE)" "0,1,2,3,4,5,6,7"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 18. "  DAC2_CLK_SEL_2 , DAC2 parameter for channel2. Select the edge of the analog clock 0(def)    positive edge of clock sample 1          negative edge of clock sample" "0,1"
      BITFLD.LONG 0x00 17. "         DAC2_OUT_SEL_1 , DAC2 parameter for channel1. Reserved" "0,1"
      BITFLD.LONG 0x00 13.--16. "  DAC2_RSV_1 , DAC2 parameter for channel1. Reserved bits" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
      BITFLD.LONG 0x00 10.--12. "  DAC2_PCTRL_1 , DAC2 parameter for channel1. [2],Select the edge of the digital clock 0(def)    positive edge of clock sample 1            negative edge of clock sample                                                                   [1:0],Choose DAC output voltage level  00   500mV(SE) 01    625mV(SE) 10    360mV(SE) 11    420mV(SE)" "0,1,2,3,4,5,6,7"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 9. "  DAC2_CLK_SEL_1 , DAC2 parameter for channel1. Select the edge of the analog clock 0(def)    positive edge of clock sample 1          negative edge of clock sample" "0,1"
      BITFLD.LONG 0x00 8. "         DAC2_OUT_SEL_0 , DAC2 parameter for channel0. Reserved" "0,1"
      BITFLD.LONG 0x00 4.--7. "  DAC2_RSV_0 , DAC2 parameter for channel0. Reserved bits" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
      BITFLD.LONG 0x00 1.--3. "  DAC2_PCTRL_0 , DAC2 parameter for channel0. [2],Select the edge of the digital clock 0(def)    positive edge of clock sample 1            negative edge of clock sample                                                                   [1:0],Choose DAC output voltage level  00   500mV(SE) 01    625mV(SE) 10    360mV(SE) 11    420mV(SE)" "0,1,2,3,4,5,6,7"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 0. "  DAC2_CLK_SEL_0 , DAC2 parameter for channel0. Select the edge of the analog clock 0(def)    positive edge of clock sample 1          negative edge of clock sample" "0,1"
  GROUP.LONG 0x00A0++0x3 "0x02070000 + 0x00A0"
    LINE.LONG 0x00 "MDAR_DAC2_CTR10"
      BITFLD.LONG 0x00 27.--31. "  Reserved       , Reserved" "Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved"
      BITFLD.LONG 0x00 26. "  DAC2_OUT_SEL_5 , DAC2 parameter for channel5. Reserved" "0,1"
      BITFLD.LONG 0x00 22.--25. "  DAC2_RSV_5 , DAC2 parameter for channel5. Reserved bits" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
      BITFLD.LONG 0x00 19.--21. "  DAC2_PCTRL_5 , DAC2 parameter for channel5. [2],Select the edge of the digital clock 0(def)    positive edge of clock sample 1            negative edge of clock sample                                                                   [1:0],Choose DAC output voltage level  00   500mV(SE) 01    625mV(SE) 10    360mV(SE) 11    420mV(SE)" "0,1,2,3,4,5,6,7"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 18. "  DAC2_CLK_SEL_5 , DAC2 parameter for channel5. Select the edge of the analog clock 0(def)    positive edge of clock sample 1          negative edge of clock sample" "0,1"
      BITFLD.LONG 0x00 17. "         DAC2_OUT_SEL_4 , DAC2 parameter for channel4. Reserved" "0,1"
      BITFLD.LONG 0x00 13.--16. "  DAC2_RSV_4 , DAC2 parameter for channel4. Reserved bits" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
      BITFLD.LONG 0x00 10.--12. "  DAC2_PCTRL_4 , DAC2 parameter for channel4. [2],Select the edge of the digital clock 0(def)    positive edge of clock sample 1            negative edge of clock sample                                                                   [1:0],Choose DAC output voltage level  00   500mV(SE) 01    625mV(SE) 10    360mV(SE) 11    420mV(SE)" "0,1,2,3,4,5,6,7"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 9. "  DAC2_CLK_SEL_4 , DAC2 parameter for channel4. Select the edge of the analog clock 0(def)    positive edge of clock sample 1          negative edge of clock sample" "0,1"
      BITFLD.LONG 0x00 8. "         DAC2_OUT_SEL_3 , DAC2 parameter for channel3. Reserved" "0,1"
      BITFLD.LONG 0x00 4.--7. "  DAC2_RSV_3 , DAC2 parameter for channel3. Reserved bits" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
      BITFLD.LONG 0x00 1.--3. "  DAC2_PCTRL_3 , DAC2 parameter for channel3. [2],Select the edge of the digital clock 0(def)    positive edge of clock sample 1            negative edge of clock sample                                                                   [1:0],Choose DAC output voltage level  00   500mV(SE) 01    625mV(SE) 10    360mV(SE) 11    420mV(SE)" "0,1,2,3,4,5,6,7"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 0. "  DAC2_CLK_SEL_3 , DAC2 parameter for channel3. Select the edge of the analog clock 0(def)    positive edge of clock sample 1          negative edge of clock sample" "0,1"
  GROUP.LONG 0x00A4++0x3 "0x02070000 + 0x00A4"
    LINE.LONG 0x00 "MDAR_ADC2_CTR0"
      BITFLD.LONG 0x00 31. "  ADC2_SOFT_RST     , " "0,1"
      BITFLD.LONG 0x00 25.--30. "  ADC2_DLL_OUT , ADC2 DLL data from analog part." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
      BITFLD.LONG 0x00 11.--24. "  ADC2_CALRDOUT , ADC2 calibration data from analog part." "none"
      BITFLD.LONG 0x00 10. "   ADC2_DLL_SOFT_RST , " "0,1"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 9. "  ADC2_CAL_SOFT_RST , " "0,1"
      BITFLD.LONG 0x00 8. "  ADC2_CALRD   , ADC2 Cap calibration read enable, high effective, default 0" "0,1"
      BITFLD.LONG 0x00 7. "   ADC2_CALEN    , ADC2 Cap calibration Enable, high effective, default 0;" "0,1"
      BITFLD.LONG 0x00 1.--6. "  ADC2_CALADDR      , ADC2 Cap calibration address, Default:000000" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 0. "  ADC2_DEBUG_EN     , ADC2 debug mode enable, high effective, default 0" "0,1"
  GROUP.LONG 0x00A8++0x3 "0x02070000 + 0x00A8"
    LINE.LONG 0x00 "MDAR_ADC2_CTR00"
      BITFLD.LONG 0x00 16.--31. "  ADC2_RSV_1 , Reserved" "none"
      BITFLD.LONG 0x00 0.--15. "  ADC2_RSV_0 , Reserved" "none"
  GROUP.LONG 0x00AC++0x3 "0x02070000 + 0x00AC"
    LINE.LONG 0x00 "MDAR_ADC2_CTR01"
      BITFLD.LONG 0x00 31. "  Reserved       , Reserved" "Reserved,Reserved"
      BITFLD.LONG 0x00 30. "  ADC2_DIG_CLK_SEL_0 , ADC2 parameter of channel0.  digital clk Sel, default 0" "0,1"
      BITFLD.LONG 0x00 29. "   ADC2_VCM_SEL_0    , ADC2 parameter of channel0.  VCM Sel Signal, default 1 (low VCM voltage)" "0,1"
      BITFLD.LONG 0x00 27.--28. "                            ADC2_DELAY_CAP_0   , ADC2 parameter of channel0. delay cap sel, 0:high speed, default 10;" "high speed- default,1,2,3"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 25.--26. "  ADC2_BIT_SEL_0 , ADC2 parameter of channel0.  bit sel, default 0; 00:14 bits; 01 :13bits, 10:12 bits, 11:11bits" "1,1,2,3"
      BITFLD.LONG 0x00 23.--24. "         ADC2_VREF_SEL_0    , ADC2 parameter of channel0. Vref sel; default 2;" "0,1,2,3"
      BITFLD.LONG 0x00 21.--22. "   ADC2_VREF_BOOST_0 , ADC2 parameter of channel0. vref boost speed, default 11; 00:min current, 11:max current" "min current-,1,2,3"
      BITFLD.LONG 0x00 19.--20. "                 ADC2_QUANT_BOOST_0 , ADC2 parameter of channel0. quant boost speed, default 11;  00: min current; 11:max current" "min current;,1,2,3"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 18. "  ADC2_DLLRD_0   , ADC2 parameter of channel0. DLL read enable, high effective, default 0" "0,1"
      BITFLD.LONG 0x00 17. "         ADC2_DLLWR_0       , ADC2 parameter of channel0. DLL write enable, high effective, default 0" "0,1"
      BITFLD.LONG 0x00 16. "   ADC2_DLLEN_0      , ADC2 parameter of channel0. DLL enable, high effective, default 1" "0,1"
      BITFLD.LONG 0x00 15. "                            ADC2_CSBC          , 1:the mrda ADC2 calibration data formate is the 2's complement code format; 0:the mrda ADC2 calibration data formate is the offset binary code. Should be 1 in the present system." "the mrda ADC,the mrda ADC"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 14. "  ADC2_IQSWAP    , ADC2 IQ switch, active high" "0,1"
      BITFLD.LONG 0x00 8.--13. "         ADC2_DLLOOF_0      , ADC2 parameter of channel0. DLL offset input, default 0" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
      BITFLD.LONG 0x00 7. "  ADC2_OSBC         , 1:the mrda output data of ADC2 is in the 2's complement code format; 0:the mrda output data of ADC2 is in the offset binary code. Should be 1 in the present system." "the mrda output data of ADC,the mrda output data of ADC"
      BITFLD.LONG 0x00 6. "  ADC2_ISBC          , 1:the superadc1 output data is in the 2's complement code format; 0:the superadc1 output data is in the offset binary code. Should be 0 in the present system." "the superadc,the superadc"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 0.--5. "  ADC2_DLLIN_0   , ADC2 parameter of channel0. DLL INPUT, default 0" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
  GROUP.LONG 0x00B0++0x3 "0x02070000 + 0x00B0"
    LINE.LONG 0x00 "MDAR_ADC2_CTR02"
      BITFLD.LONG 0x00 31. "  Reserved       , Reserved" "Reserved,Reserved"
      BITFLD.LONG 0x00 30. "  ADC2_DIG_CLK_SEL_1 , ADC2 parameter of channel1.  digital clk Sel, default 0" "0,1"
      BITFLD.LONG 0x00 29. "   ADC2_VCM_SEL_1    , ADC2 parameter of channel1.  VCM Sel Signal, default 1 (low VCM voltage)" "0,1"
      BITFLD.LONG 0x00 27.--28. "             ADC2_DELAY_CAP_1   , ADC2 parameter of channel1. delay cap sel, 0:high speed, default 10;" "high speed- default,1,2,3"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 25.--26. "  ADC2_BIT_SEL_1 , ADC2 parameter of channel1.  bit sel, default 0; 00:14 bits; 01 :13bits, 10:12 bits, 11:11bits" "1,1,2,3"
      BITFLD.LONG 0x00 23.--24. "         ADC2_VREF_SEL_1    , ADC2 parameter of channel1. Vref sel; default 2;" "0,1,2,3"
      BITFLD.LONG 0x00 21.--22. "   ADC2_VREF_BOOST_1 , ADC2 parameter of channel1. vref boost speed, default 11; 00:min current, 11:max current" "min current-,1,2,3"
      BITFLD.LONG 0x00 19.--20. "  ADC2_QUANT_BOOST_1 , ADC2 parameter of channel1. quant boost speed, default 11;  00: min current; 11:max current" "min current;,1,2,3"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 18. "  ADC2_DLLRD_1   , ADC2 parameter of channel1. DLL read enable, high effective, default 0" "0,1"
      BITFLD.LONG 0x00 17. "         ADC2_DLLWR_1       , ADC2 parameter of channel1. DLL write enable, high effective, default 0" "0,1"
      BITFLD.LONG 0x00 16. "   ADC2_DLLEN_1      , ADC2 parameter of channel1. DLL enable, high effective, default 1" "0,1"
      BITFLD.LONG 0x00 15. "             Reserved           , Reserved" "Reserved,Reserved"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 14. "  Reserved       , Reserved" "Reserved,Reserved"
      BITFLD.LONG 0x00 8.--13. "  ADC2_DLLOOF_1      , ADC2 parameter of channel1. DLL offset input, default 0" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
      BITFLD.LONG 0x00 7. "  Reserved          , Reserved" "Reserved,Reserved"
      BITFLD.LONG 0x00 6. "      Reserved           , Reserved" "Reserved,Reserved"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 0.--5. "  ADC2_DLLIN_1   , ADC2 parameter of channel1. DLL INPUT, default 0" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
  GROUP.LONG 0x00B4++0x3 "0x02070000 + 0x00B4"
    LINE.LONG 0x00 "MDAR_ADC2_CTR10"
      BITFLD.LONG 0x00 16.--31. "  ADC2_RSV_3 , Reserved" "none"
      BITFLD.LONG 0x00 0.--15. "  ADC2_RSV_2 , Reserved" "none"
  GROUP.LONG 0x00B8++0x3 "0x02070000 + 0x00B8"
    LINE.LONG 0x00 "MDAR_ADC2_CTR11"
      BITFLD.LONG 0x00 31. "  Reserved       , Reserved" "Reserved,Reserved"
      BITFLD.LONG 0x00 30. "  ADC2_DIG_CLK_SEL_2 , ADC2 parameter of channel2.  digital clk Sel, default 0" "0,1"
      BITFLD.LONG 0x00 29. "   ADC2_VCM_SEL_2    , ADC2 parameter of channel2.  VCM Sel Signal, default 1 (low VCM voltage)" "0,1"
      BITFLD.LONG 0x00 27.--28. "             ADC2_DELAY_CAP_2   , ADC2 parameter of channel2. delay cap sel, 0:high speed, default 10;" "high speed- default,1,2,3"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 25.--26. "  ADC2_BIT_SEL_2 , ADC2 parameter of channel2.  bit sel, default 0; 00:14 bits; 01 :13bits, 10:12 bits, 11:11bits" "1,1,2,3"
      BITFLD.LONG 0x00 23.--24. "         ADC2_VREF_SEL_2    , ADC2 parameter of channel2. Vref sel; default 0;" "0,1,2,3"
      BITFLD.LONG 0x00 21.--22. "   ADC2_VREF_BOOST_2 , ADC2 parameter of channel2. vref boost speed, default 11; 00:min current, 11:max current" "min current-,1,2,3"
      BITFLD.LONG 0x00 19.--20. "  ADC2_QUANT_BOOST_2 , ADC2 parameter of channel2. quant boost speed, default 11;  00: min current; 11:max current" "min current;,1,2,3"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 18. "  ADC2_DLLRD_2   , ADC2 parameter of channel2. DLL read enable, high effective, default 0" "0,1"
      BITFLD.LONG 0x00 17. "         ADC2_DLLWR_2       , ADC2 parameter of channel2. DLL write enable, high effective, default 0" "0,1"
      BITFLD.LONG 0x00 16. "   ADC2_DLLEN_2      , ADC2 parameter of channel2. DLL enable, high effective, default 1" "0,1"
      BITFLD.LONG 0x00 15. "             Reserved           , Reserved" "Reserved,Reserved"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 14. "  Reserved       , Reserved" "Reserved,Reserved"
      BITFLD.LONG 0x00 8.--13. "  ADC2_DLLOOF_2      , ADC2 parameter of channel2. DLL offset input, default 0" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
      BITFLD.LONG 0x00 7. "  Reserved          , Reserved" "Reserved,Reserved"
      BITFLD.LONG 0x00 6. "      Reserved           , Reserved" "Reserved,Reserved"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 0.--5. "  ADC2_DLLIN_2   , ADC2 parameter of channel2. DLL INPUT, default 0" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
  GROUP.LONG 0x00BC++0x3 "0x02070000 + 0x00BC"
    LINE.LONG 0x00 "MDAR_ADC2_CTR12"
      BITFLD.LONG 0x00 31. "  Reserved       , Reserved" "Reserved,Reserved"
      BITFLD.LONG 0x00 30. "  ADC2_DIG_CLK_SEL_3 , ADC2 parameter of channel3.  digital clk Sel, default 0" "0,1"
      BITFLD.LONG 0x00 29. "   ADC2_VCM_SEL_3    , ADC2 parameter of channel3.  VCM Sel Signal, default 1 (low VCM voltage)" "0,1"
      BITFLD.LONG 0x00 27.--28. "             ADC2_DELAY_CAP_3   , ADC2 parameter of channel3. delay cap sel, 0:high speed, default 10;" "high speed- default,1,2,3"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 25.--26. "  ADC2_BIT_SEL_3 , ADC2 parameter of channel3.  bit sel, default 0; 00:14 bits; 01 :13bits, 10:12 bits, 11:11bits" "1,1,2,3"
      BITFLD.LONG 0x00 23.--24. "         ADC2_VREF_SEL_3    , ADC2 parameter of channel3. Vref sel; default 2;" "0,1,2,3"
      BITFLD.LONG 0x00 21.--22. "   ADC2_VREF_BOOST_3 , ADC2 parameter of channel3. vref boost speed, default 11; 00:min current, 11:max current" "min current-,1,2,3"
      BITFLD.LONG 0x00 19.--20. "  ADC2_QUANT_BOOST_3 , ADC2 parameter of channel3. quant boost speed, default 11;  00: min current; 11:max current" "min current;,1,2,3"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 18. "  ADC2_DLLRD_3   , ADC2 parameter of channel3. DLL read enable, high effective, default 0" "0,1"
      BITFLD.LONG 0x00 17. "         ADC2_DLLWR_3       , ADC2 parameter of channel3. DLL write enable, high effective, default 0" "0,1"
      BITFLD.LONG 0x00 16. "   ADC2_DLLEN_3      , ADC2 parameter of channel3. DLL enable, high effective, default 1" "0,1"
      BITFLD.LONG 0x00 15. "             Reserved           , Reserved" "Reserved,Reserved"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 14. "  Reserved       , Reserved" "Reserved,Reserved"
      BITFLD.LONG 0x00 8.--13. "  ADC2_DLLOOF_3      , ADC2 parameter of channel3. DLL offset input, default 0" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
      BITFLD.LONG 0x00 7. "  Reserved          , Reserved" "Reserved,Reserved"
      BITFLD.LONG 0x00 6. "      Reserved           , Reserved" "Reserved,Reserved"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 0.--5. "  ADC2_DLLIN_3   , ADC2 parameter of channel3. DLL INPUT, default 0" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
  GROUP.LONG 0x00C0++0x3 "0x02070000 + 0x00C0"
    LINE.LONG 0x00 "MDAR_ADC2_CTR20"
      BITFLD.LONG 0x00 16.--31. "  ADC2_RSV_5 , Reserved" "none"
      BITFLD.LONG 0x00 0.--15. "  ADC2_RSV_4 , Reserved" "none"
  GROUP.LONG 0x00C4++0x3 "0x02070000 + 0x00C4"
    LINE.LONG 0x00 "MDAR_ADC2_CTR21"
      BITFLD.LONG 0x00 31. "  Reserved       , Reserved" "Reserved,Reserved"
      BITFLD.LONG 0x00 30. "  ADC2_DIG_CLK_SEL_4 , ADC2 parameter of channel4.  digital clk Sel, default 0" "0,1"
      BITFLD.LONG 0x00 29. "   ADC2_VCM_SEL_4    , ADC2 parameter of channel4.  VCM Sel Signal, default 1 (low VCM voltage)" "0,1"
      BITFLD.LONG 0x00 27.--28. "             ADC2_DELAY_CAP_4   , ADC2 parameter of channel4. delay cap sel, 0:high speed, default 10;" "high speed- default,1,2,3"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 25.--26. "  ADC2_BIT_SEL_4 , ADC2 parameter of channel4.  bit sel, default 0; 00:14 bits; 01 :13bits, 10:12 bits, 11:11bits" "1,1,2,3"
      BITFLD.LONG 0x00 23.--24. "         ADC2_VREF_SEL_4    , ADC2 parameter of channel4. Vref sel; default 2;" "0,1,2,3"
      BITFLD.LONG 0x00 21.--22. "   ADC2_VREF_BOOST_4 , ADC2 parameter of channel4. vref boost speed, default 11; 00:min current, 11:max current" "min current-,1,2,3"
      BITFLD.LONG 0x00 19.--20. "  ADC2_QUANT_BOOST_4 , ADC2 parameter of channel4. quant boost speed, default 11;  00: min current; 11:max current" "min current;,1,2,3"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 18. "  ADC2_DLLRD_4   , ADC2 parameter of channel4. DLL read enable, high effective, default 0" "0,1"
      BITFLD.LONG 0x00 17. "         ADC2_DLLWR_4       , ADC2 parameter of channel4. DLL write enable, high effective, default 0" "0,1"
      BITFLD.LONG 0x00 16. "   ADC2_DLLEN_4      , ADC2 parameter of channel4. DLL enable, high effective, default 1" "0,1"
      BITFLD.LONG 0x00 15. "             Reserved           , Reserved" "Reserved,Reserved"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 14. "  Reserved       , Reserved" "Reserved,Reserved"
      BITFLD.LONG 0x00 8.--13. "  ADC2_DLLOOF_4      , ADC2 parameter of channel4. DLL offset input, default 0" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
      BITFLD.LONG 0x00 7. "  Reserved          , Reserved" "Reserved,Reserved"
      BITFLD.LONG 0x00 6. "      Reserved           , Reserved" "Reserved,Reserved"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 0.--5. "  ADC2_DLLIN_4   , ADC2 parameter of channel4. DLL INPUT, default 0" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
  GROUP.LONG 0x00C8++0x3 "0x02070000 + 0x00C8"
    LINE.LONG 0x00 "MDAR_ADC2_CTR22"
      BITFLD.LONG 0x00 31. "  Reserved       , Reserved" "Reserved,Reserved"
      BITFLD.LONG 0x00 30. "  ADC2_DIG_CLK_SEL_5 , ADC2 parameter of channel5.  digital clk Sel, default 0" "0,1"
      BITFLD.LONG 0x00 29. "   ADC2_VCM_SEL_5    , ADC2 parameter of channel5.  VCM Sel Signal, default 1 (low VCM voltage)" "0,1"
      BITFLD.LONG 0x00 27.--28. "             ADC2_DELAY_CAP_5   , ADC2 parameter of channel5. delay cap sel, 0:high speed, default 10;" "high speed- default,1,2,3"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 25.--26. "  ADC2_BIT_SEL_5 , ADC2 parameter of channel5.  bit sel, default 0; 00:14 bits; 01 :13bits, 10:12 bits, 11:11bits" "1,1,2,3"
      BITFLD.LONG 0x00 23.--24. "         ADC2_VREF_SEL_5    , ADC2 parameter of channel5. Vref sel; default 2;" "0,1,2,3"
      BITFLD.LONG 0x00 21.--22. "   ADC2_VREF_BOOST_5 , ADC2 parameter of channel5. vref boost speed, default 11; 00:min current, 11:max current" "min current-,1,2,3"
      BITFLD.LONG 0x00 19.--20. "  ADC2_QUANT_BOOST_5 , ADC2 parameter of channel5. quant boost speed, default 11;  00: min current; 11:max current" "min current;,1,2,3"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 18. "  ADC2_DLLRD_5   , ADC2 parameter of channel5. DLL read enable, high effective, default 0" "0,1"
      BITFLD.LONG 0x00 17. "         ADC2_DLLWR_5       , ADC2 parameter of channel5. DLL write enable, high effective, default 0" "0,1"
      BITFLD.LONG 0x00 16. "   ADC2_DLLEN_5      , ADC2 parameter of channel5. DLL enable, high effective, default 1" "0,1"
      BITFLD.LONG 0x00 15. "             Reserved           , Reserved" "Reserved,Reserved"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 14. "  Reserved       , Reserved" "Reserved,Reserved"
      BITFLD.LONG 0x00 8.--13. "  ADC2_DLLOOF_5      , ADC2 parameter of channel5. DLL offset input, default 0" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
      BITFLD.LONG 0x00 7. "  Reserved          , Reserved" "Reserved,Reserved"
      BITFLD.LONG 0x00 6. "      Reserved           , Reserved" "Reserved,Reserved"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 0.--5. "  ADC2_DLLIN_5   , ADC2 parameter of channel5. DLL INPUT, default 0" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
  GROUP.LONG 0x00D0++0x3 "0x02070000 + 0x00D0"
    LINE.LONG 0x00 "MDAR_DAC3_CTR1"
      BITFLD.LONG 0x00 16.--31. "  DAC3_WD_OVR     , DAC3 parameter control; Bit weight override write input Default 16’b0" "none"
      BITFLD.LONG 0x00 4.--7. "   DAC3_WADDR_OVR , DAC3 parameter control; Bit weight override address Default 0000" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
      BITFLD.LONG 0x00 3. "  Reserved , Reserved" "Reserved,Reserved"
      BITFLD.LONG 0x00 2. "  DAC3_WLE_OVR , DAC3 parameter control; Bit weight override load enable 0(def)      unable  1             enable" "0,1"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 1. "  DAC3_W_OVR_I_QN , DAC3 parameter control; Select which channel to override 0(def)      Channel Q 1            Channel I" "0,1"
      BITFLD.LONG 0x00 0. "  DAC3_W_OVR_EN  , DAC3 parameter control; Enable Bit weight register override  0(def)      unable  1            enable" "0,1"
  GROUP.LONG 0x00D4++0x3 "0x02070000 + 0x00D4"
    LINE.LONG 0x00 "MDAR_DAC3_CTR2"
      BITFLD.LONG 0x00 23. "  DAC3_AUTO_RST   , " "0,1"
      BITFLD.LONG 0x00 22. "  DAC3_SOFT_RST  , " "0,1"
      BITFLD.LONG 0x00 21. "  DAC3_OSBC   , This bit determinate the input data's format of the DAC3 weight process function. 1 means the 2’s complement code; 0 means offset binary code. This bit must set to 1." "0,1"
      BITFLD.LONG 0x00 20. "  DAC3_ISBC      , When the output data of the communication system's TX is format in 2’s complement code, this bit must set to1, otherwise this bit should be 0." "0,1"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 19. "  DAC3_OVR_EN_CAL , DAC3 parameter control;" "0,1"
      BITFLD.LONG 0x00 18. "  DAC3_EN_OOSCAL , DAC3 parameter control;" "0,1"
      BITFLD.LONG 0x00 17. "  DAC3_IQSWAP , DAC3 IQ switch" "0,1"
      BITFLD.LONG 0x00 16. "  DAC3_CAL_START , DAC3 self calibration start" "0,1"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 8.--15. "  DAC3_OFFSETI    , DAC3 parameter control;" "none"
      BITFLD.LONG 0x00 0.--7. "   DAC3_OFFSETQ   , DAC3 parameter control;" "none"
  GROUP.LONG 0x00D8++0x3 "0x02070000 + 0x00D8"
    LINE.LONG 0x00 "MDAR_DAC3_CTR3"
      BITFLD.LONG 0x00 28.--31. "  Reserved , Reserved" "Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved"
      BITFLD.LONG 0x00 16.--27. "  DAC3_Q_DC , DAC3  Q  DC bias;" "none"
      BITFLD.LONG 0x00 12.--15. "  Reserved , Reserved" "Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved"
      BITFLD.LONG 0x00 0.--11. "  DAC3_I_DC , DAC3  I DC bias;" "none"
      TEXTLINE "                           "
  GROUP.LONG 0x00DC++0x3 "0x02070000 + 0x00DC"
    LINE.LONG 0x00 "MDAR_DAC3_CTR4"
      BITFLD.LONG 0x00 28.--31. "  Reserved , Reserved" "Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved"
      BITFLD.LONG 0x00 16.--27. "  DAC3_I_CAL , DAC3 I input when 'ADA3_MODE_SEL = 1'b1'." "none"
      BITFLD.LONG 0x00 12.--15. "  Reserved , Reserved" "Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved"
      BITFLD.LONG 0x00 0.--11. "  DAC3_Q_CAL , DAC3 Q input when 'ADA3_MODE_SEL = 1'b1'." "none"
      TEXTLINE "                           "
  GROUP.LONG 0x00E0++0x3 "0x02070000 + 0x00E0"
    LINE.LONG 0x00 "MDAR_DAC3_STS0"
      BITFLD.LONG 0x00 16.--31. "  DAC3_WTI , DAC3 parameter control;" "none"
      BITFLD.LONG 0x00 0.--15. "  DAC3_WTQ , DAC3 parameter control;" "none"
  GROUP.LONG 0x00E4++0x3 "0x02070000 + 0x00E4"
    LINE.LONG 0x00 "MDAR_DAC3_STS1"
      BITFLD.LONG 0x00 17.--18. "  DAC3_DA_STATE , DAC3 parameter status" "0,1,2,3"
      BITFLD.LONG 0x00 16. "  DAC3_DONE , DAC3 parameter control, indicating DAC3 calibration done" "0,1"
      BITFLD.LONG 0x00 0.--15. "  DAC3_WQ_OVR , DAC3 parameter status" "none"
  GROUP.LONG 0x00E8++0x3 "0x02070000 + 0x00E8"
    LINE.LONG 0x00 "MDAR_CAL3_CTR0"
      BITFLD.LONG 0x00 16.--23. "  ADC3_CLK_CAL_DLY , In ADA3 loop calibration, ADC3 CLK and DAC3 CLK are both 13MHz, but ADC3 CLK should have some delay time with DAC3 CLK.. ADC3_CLK_CAL_DLY[6:0]: the delay time selection. 1 unit is 0.1ns delay. ADC3_CLK_CAL_DLY[7]: invert DAC3_CLK input." "none"
      BITFLD.LONG 0x00 8.--15. "                      ADA3_CAL_WAIT , After ADA3_CAL_START, need wait (ADAC_CAL_WAIT + 1) cycle of 13MHz, then start  the calibration calculation start." "none"
      BITFLD.LONG 0x00 7. "          Reserved    , Reserved" "Reserved,Reserved"
      BITFLD.LONG 0x00 6. "           CLK_ADA3_CAL_EN , ADA3 calibration clock enable 0: disable; 1: enable. Make sure to disable ADA3 calibration clock before switch between normal mode and calibration mode." "disable;,enable. Make sure to disable ADA"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 5. "  DAC3_PD_CAL      , DAC3 power down control when 'ADA3_MODE_SEL = 1'b1'. 0: Force enable DAC3; 1: Force power down DAC3" "Force enable DAC,Force power down DAC"
      BITFLD.LONG 0x00 4. "  Reserved      , Reserved" "Reserved,Reserved"
      BITFLD.LONG 0x00 3. "  ADC3_EN_CAL , ADC3 enable control when 'ADA3_MODE_SEL = 1'b1'. 0: Force disable ADC3; 1: Force enable ADC3" "Force disable ADC,Force enable ADC"
      BITFLD.LONG 0x00 2. "  Reserved        , Reserved" "Reserved,Reserved"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 1. "  ADC3_CAL         , ADC3 dc offset calibration 0: normal mode 1: calibration mode" "normal mode,calibration mode"
      BITFLD.LONG 0x00 0. "      ADA3_MODE_SEL , ADA3 work mode selection 0: normal; 1: calibration mode" "normal;,calibration mode"
  GROUP.LONG 0x00EC++0x3 "0x02070000 + 0x00EC"
    LINE.LONG 0x00 "MDAR_CAL3_CTR1"
      BITFLD.LONG 0x00 29.--31. "  Reserved , Reserved" "Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved"
      BITFLD.LONG 0x00 16.--28. "  ADC3_Q_DC , ADC3 Q DC offset" "none"
      BITFLD.LONG 0x00 13.--15. "  Reserved , Reserved" "Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved"
      BITFLD.LONG 0x00 0.--12. "  ADC3_I_DC , ADC3 I DC offset" "none"
      TEXTLINE "                           "
  GROUP.LONG 0x00F0++0x3 "0x02070000 + 0x00F0"
    LINE.LONG 0x00 "MDAR_CAL3_CTR3"
      BITFLD.LONG 0x00 0. "  ADA3_CAL_START , Write 1 to start ADA3 calibration. It is self-cleared" "0,1"
  GROUP.LONG 0x00F4++0x3 "0x02070000 + 0x00F4"
    LINE.LONG 0x00 "MDAR_CAL3_STS0"
      BITFLD.LONG 0x00 31. "  ADA3_CAL_DONE , ADA3 calibration done. Active high" "0,1"
      BITFLD.LONG 0x00 0.--19. "  ADC3_CAL_I_SUM , Sum of 128 ADC3_I data" "none"
  GROUP.LONG 0x00F8++0x3 "0x02070000 + 0x00F8"
    LINE.LONG 0x00 "MDAR_CAL3_STS1"
      BITFLD.LONG 0x00 0.--19. "  ADC3_CAL_Q_SUM , Sum of 128 ADC3_Q data" "none"
  GROUP.LONG 0x00FC++0x3 "0x02070000 + 0x00FC"
    LINE.LONG 0x00 "MDAR_DAC3_CTR00"
      BITFLD.LONG 0x00 27.--31. "  Reserved       , Reserved" "Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved"
      BITFLD.LONG 0x00 26. "  DAC3_OUT_SEL_2 , DAC3 parameter for channel2. Reserved" "0,1"
      BITFLD.LONG 0x00 22.--25. "  DAC3_RSV_2 , DAC3 parameter for channel2. Reserved bits" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
      BITFLD.LONG 0x00 19.--21. "  DAC3_PCTRL_2 , DAC3 parameter for channel2. [2],Select the edge of the digital clock 0(def)    positive edge of clock sample 1            negative edge of clock sample                                                                   [1:0],Choose DAC output voltage level  00   500mV(SE) 01    625mV(SE) 10    360mV(SE) 11    420mV(SE)" "0,1,2,3,4,5,6,7"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 18. "  DAC3_CLK_SEL_2 , DAC3 parameter for channel2. Select the edge of the analog clock 0(def)    positive edge of clock sample 1          negative edge of clock sample" "0,1"
      BITFLD.LONG 0x00 17. "         DAC3_OUT_SEL_1 , DAC3 parameter for channel1. Reserved" "0,1"
      BITFLD.LONG 0x00 13.--16. "  DAC3_RSV_1 , DAC3 parameter for channel1. Reserved bits" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
      BITFLD.LONG 0x00 10.--12. "  DAC3_PCTRL_1 , DAC3 parameter for channel1. [2],Select the edge of the digital clock 0(def)    positive edge of clock sample 1            negative edge of clock sample                                                                   [1:0],Choose DAC output voltage level  00   500mV(SE) 01    625mV(SE) 10    360mV(SE) 11    420mV(SE)" "0,1,2,3,4,5,6,7"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 9. "  DAC3_CLK_SEL_1 , DAC3 parameter for channel1. Select the edge of the analog clock 0(def)    positive edge of clock sample 1          negative edge of clock sample" "0,1"
      BITFLD.LONG 0x00 8. "         DAC3_OUT_SEL_0 , DAC3 parameter for channel0. Reserved" "0,1"
      BITFLD.LONG 0x00 4.--7. "  DAC3_RSV_0 , DAC3 parameter for channel0. Reserved bits" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
      BITFLD.LONG 0x00 1.--3. "  DAC3_PCTRL_0 , DAC3 parameter for channel0. [2],Select the edge of the digital clock 0(def)    positive edge of clock sample 1            negative edge of clock sample                                                                   [1:0],Choose DAC output voltage level  00   500mV(SE) 01    625mV(SE) 10    360mV(SE) 11    420mV(SE)" "0,1,2,3,4,5,6,7"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 0. "  DAC3_CLK_SEL_0 , DAC3 parameter for channel0. Select the edge of the analog clock 0(def)    positive edge of clock sample 1          negative edge of clock sample" "0,1"
  GROUP.LONG 0x0100++0x3 "0x02070000 + 0x0100"
    LINE.LONG 0x00 "MDAR_DAC3_CTR10"
      BITFLD.LONG 0x00 27.--31. "  Reserved       , Reserved" "Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved"
      BITFLD.LONG 0x00 26. "  DAC3_OUT_SEL_5 , DAC3 parameter for channel5. Reserved" "0,1"
      BITFLD.LONG 0x00 22.--25. "  DAC3_RSV_5 , DAC3 parameter for channel5. Reserved bits" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
      BITFLD.LONG 0x00 19.--21. "  DAC3_PCTRL_5 , DAC3 parameter for channel5. [2],Select the edge of the digital clock 0(def)    positive edge of clock sample 1            negative edge of clock sample                                                                   [1:0],Choose DAC output voltage level  00   500mV(SE) 01    625mV(SE) 10    360mV(SE) 11    420mV(SE)" "0,1,2,3,4,5,6,7"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 18. "  DAC3_CLK_SEL_5 , DAC3 parameter for channel5. Select the edge of the analog clock 0(def)    positive edge of clock sample 1          negative edge of clock sample" "0,1"
      BITFLD.LONG 0x00 17. "         DAC3_OUT_SEL_4 , DAC3 parameter for channel4. Reserved" "0,1"
      BITFLD.LONG 0x00 13.--16. "  DAC3_RSV_4 , DAC3 parameter for channel4. Reserved bits" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
      BITFLD.LONG 0x00 10.--12. "  DAC3_PCTRL_4 , DAC3 parameter for channel4. [2],Select the edge of the digital clock 0(def)    positive edge of clock sample 1            negative edge of clock sample                                                                   [1:0],Choose DAC output voltage level  00   500mV(SE) 01    625mV(SE) 10    360mV(SE) 11    420mV(SE)" "0,1,2,3,4,5,6,7"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 9. "  DAC3_CLK_SEL_4 , DAC3 parameter for channel4. Select the edge of the analog clock 0(def)    positive edge of clock sample 1          negative edge of clock sample" "0,1"
      BITFLD.LONG 0x00 8. "         DAC3_OUT_SEL_3 , DAC3 parameter for channel3. Reserved" "0,1"
      BITFLD.LONG 0x00 4.--7. "  DAC3_RSV_3 , DAC3 parameter for channel3. Reserved bits" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
      BITFLD.LONG 0x00 1.--3. "  DAC3_PCTRL_3 , DAC3 parameter for channel3. [2],Select the edge of the digital clock 0(def)    positive edge of clock sample 1            negative edge of clock sample                                                                   [1:0],Choose DAC output voltage level  00   500mV(SE) 01    625mV(SE) 10    360mV(SE) 11    420mV(SE)" "0,1,2,3,4,5,6,7"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 0. "  DAC3_CLK_SEL_3 , DAC3 parameter for channel3. Select the edge of the analog clock 0(def)    positive edge of clock sample 1          negative edge of clock sample" "0,1"
  GROUP.LONG 0x0104++0x3 "0x02070000 + 0x0104"
    LINE.LONG 0x00 "MDAR_ADC3_CTR0"
      BITFLD.LONG 0x00 31. "  ADC3_SOFT_RST     , " "0,1"
      BITFLD.LONG 0x00 25.--30. "  ADC3_DLL_OUT , ADC3 DLL data from analog part." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
      BITFLD.LONG 0x00 11.--24. "  ADC3_CALRDOUT , ADC3 calibration data from analog part." "none"
      BITFLD.LONG 0x00 10. "   ADC3_DLL_SOFT_RST , " "0,1"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 9. "  ADC3_CAL_SOFT_RST , " "0,1"
      BITFLD.LONG 0x00 8. "  ADC3_CALRD   , ADC3 Cap calibration read enable, high effective, default 0" "0,1"
      BITFLD.LONG 0x00 7. "   ADC3_CALEN    , ADC3 Cap calibration Enable, high effective, default 0;" "0,1"
      BITFLD.LONG 0x00 1.--6. "  ADC3_CALADDR      , ADC3 Cap calibration address, Default:000000" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 0. "  ADC3_DEBUG_EN     , ADC3 debug mode enable, high effective, default 0" "0,1"
  GROUP.LONG 0x0108++0x3 "0x02070000 + 0x0108"
    LINE.LONG 0x00 "MDAR_ADC3_CTR00"
      BITFLD.LONG 0x00 16.--31. "  ADC3_RSV_1 , Reserved" "none"
      BITFLD.LONG 0x00 0.--15. "  ADC3_RSV_0 , Reserved" "none"
  GROUP.LONG 0x010C++0x3 "0x02070000 + 0x010C"
    LINE.LONG 0x00 "MDAR_ADC3_CTR01"
      BITFLD.LONG 0x00 31. "  Reserved       , Reserved" "Reserved,Reserved"
      BITFLD.LONG 0x00 30. "  ADC3_DIG_CLK_SEL_0 , ADC3 parameter of channel0.  digital clk Sel, default 0" "0,1"
      BITFLD.LONG 0x00 29. "   ADC3_VCM_SEL_0    , ADC3 parameter of channel0.  VCM Sel Signal, default 1 (low VCM voltage)" "0,1"
      BITFLD.LONG 0x00 27.--28. "                            ADC3_DELAY_CAP_0   , ADC3 parameter of channel0. delay cap sel, 0:high speed, default 10;" "high speed- default,1,2,3"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 25.--26. "  ADC3_BIT_SEL_0 , ADC3 parameter of channel0.  bit sel, default 0; 00:14 bits; 01 :13bits, 10:12 bits, 11:11bits" "1,1,2,3"
      BITFLD.LONG 0x00 23.--24. "         ADC3_VREF_SEL_0    , ADC3 parameter of channel0. Vref sel; default 2;" "0,1,2,3"
      BITFLD.LONG 0x00 21.--22. "   ADC3_VREF_BOOST_0 , ADC3 parameter of channel0. vref boost speed, default 11; 00:min current, 11:max current" "min current-,1,2,3"
      BITFLD.LONG 0x00 19.--20. "                 ADC3_QUANT_BOOST_0 , ADC3 parameter of channel0. quant boost speed, default 11;  00: min current; 11:max current" "min current;,1,2,3"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 18. "  ADC3_DLLRD_0   , ADC3 parameter of channel0. DLL read enable, high effective, default 0" "0,1"
      BITFLD.LONG 0x00 17. "         ADC3_DLLWR_0       , ADC3 parameter of channel0. DLL write enable, high effective, default 0" "0,1"
      BITFLD.LONG 0x00 16. "   ADC3_DLLEN_0      , ADC3 parameter of channel0. DLL enable, high effective, default 1" "0,1"
      BITFLD.LONG 0x00 15. "                            ADC3_CSBC          , 1:the mrda ADC3 calibration data formate is the 2's complement code format; 0:the mrda ADC3 calibration data formate is the offset binary code. Should be 1 in the present system." "the mrda ADC,the mrda ADC"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 14. "  ADC3_IQSWAP    , ADC3 IQ switch, active high" "0,1"
      BITFLD.LONG 0x00 8.--13. "         ADC3_DLLOOF_0      , ADC3 parameter of channel0. DLL offset input, default 0" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
      BITFLD.LONG 0x00 7. "  ADC3_OSBC         , 1:the mrda output data of ADC3 is in the 2's complement code format; 0:the mrda output data of ADC3 is in the offset binary code. Should be 1 in the present system." "the mrda output data of ADC,the mrda output data of ADC"
      BITFLD.LONG 0x00 6. "  ADC3_ISBC          , 1:the superadc1 output data is in the 2's complement code format; 0:the superadc1 output data is in the offset binary code. Should be 0 in the present system." "the superadc,the superadc"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 0.--5. "  ADC3_DLLIN_0   , ADC3 parameter of channel0. DLL INPUT, default 0" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
  GROUP.LONG 0x0110++0x3 "0x02070000 + 0x0110"
    LINE.LONG 0x00 "MDAR_ADC3_CTR02"
      BITFLD.LONG 0x00 31. "  Reserved       , Reserved" "Reserved,Reserved"
      BITFLD.LONG 0x00 30. "  ADC3_DIG_CLK_SEL_1 , ADC3 parameter of channel1.  digital clk Sel, default 0" "0,1"
      BITFLD.LONG 0x00 29. "   ADC3_VCM_SEL_1    , ADC3 parameter of channel1.  VCM Sel Signal, default 1 (low VCM voltage)" "0,1"
      BITFLD.LONG 0x00 27.--28. "             ADC3_DELAY_CAP_1   , ADC3 parameter of channel1. delay cap sel, 0:high speed, default 10;" "high speed- default,1,2,3"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 25.--26. "  ADC3_BIT_SEL_1 , ADC3 parameter of channel1.  bit sel, default 0; 00:14 bits; 01 :13bits, 10:12 bits, 11:11bits" "1,1,2,3"
      BITFLD.LONG 0x00 23.--24. "         ADC3_VREF_SEL_1    , ADC3 parameter of channel1. Vref sel; default 2;" "0,1,2,3"
      BITFLD.LONG 0x00 21.--22. "   ADC3_VREF_BOOST_1 , ADC3 parameter of channel1. vref boost speed, default 11; 00:min current, 11:max current" "min current-,1,2,3"
      BITFLD.LONG 0x00 19.--20. "  ADC3_QUANT_BOOST_1 , ADC3 parameter of channel1. quant boost speed, default 11;  00: min current; 11:max current" "min current;,1,2,3"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 18. "  ADC3_DLLRD_1   , ADC3 parameter of channel1. DLL read enable, high effective, default 0" "0,1"
      BITFLD.LONG 0x00 17. "         ADC3_DLLWR_1       , ADC3 parameter of channel1. DLL write enable, high effective, default 0" "0,1"
      BITFLD.LONG 0x00 16. "   ADC3_DLLEN_1      , ADC3 parameter of channel1. DLL enable, high effective, default 1" "0,1"
      BITFLD.LONG 0x00 15. "             Reserved           , Reserved" "Reserved,Reserved"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 14. "  Reserved       , Reserved" "Reserved,Reserved"
      BITFLD.LONG 0x00 8.--13. "  ADC3_DLLOOF_1      , ADC3 parameter of channel1. DLL offset input, default 0" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
      BITFLD.LONG 0x00 7. "  Reserved          , Reserved" "Reserved,Reserved"
      BITFLD.LONG 0x00 6. "      Reserved           , Reserved" "Reserved,Reserved"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 0.--5. "  ADC3_DLLIN_1   , ADC3 parameter of channel1. DLL INPUT, default 0" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
  GROUP.LONG 0x0114++0x3 "0x02070000 + 0x0114"
    LINE.LONG 0x00 "MDAR_ADC3_CTR10"
      BITFLD.LONG 0x00 16.--31. "  ADC3_RSV_3 , Reserved" "none"
      BITFLD.LONG 0x00 0.--15. "  ADC3_RSV_2 , Reserved" "none"
  GROUP.LONG 0x0118++0x3 "0x02070000 + 0x0118"
    LINE.LONG 0x00 "MDAR_ADC3_CTR11"
      BITFLD.LONG 0x00 31. "  Reserved       , Reserved" "Reserved,Reserved"
      BITFLD.LONG 0x00 30. "  ADC3_DIG_CLK_SEL_2 , ADC3 parameter of channel2.  digital clk Sel, default 0" "0,1"
      BITFLD.LONG 0x00 29. "   ADC3_VCM_SEL_2    , ADC3 parameter of channel2.  VCM Sel Signal, default 1 (low VCM voltage)" "0,1"
      BITFLD.LONG 0x00 27.--28. "             ADC3_DELAY_CAP_2   , ADC3 parameter of channel2. delay cap sel, 0:high speed, default 10;" "high speed- default,1,2,3"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 25.--26. "  ADC3_BIT_SEL_2 , ADC3 parameter of channel2.  bit sel, default 0; 00:14 bits; 01 :13bits, 10:12 bits, 11:11bits" "1,1,2,3"
      BITFLD.LONG 0x00 23.--24. "         ADC3_VREF_SEL_2    , ADC3 parameter of channel2. Vref sel; default 2;" "0,1,2,3"
      BITFLD.LONG 0x00 21.--22. "   ADC3_VREF_BOOST_2 , ADC3 parameter of channel2. vref boost speed, default 11; 00:min current, 11:max current" "min current-,1,2,3"
      BITFLD.LONG 0x00 19.--20. "  ADC3_QUANT_BOOST_2 , ADC3 parameter of channel2. quant boost speed, default 11;  00: min current; 11:max current" "min current;,1,2,3"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 18. "  ADC3_DLLRD_2   , ADC3 parameter of channel2. DLL read enable, high effective, default 0" "0,1"
      BITFLD.LONG 0x00 17. "         ADC3_DLLWR_2       , ADC3 parameter of channel2. DLL write enable, high effective, default 0" "0,1"
      BITFLD.LONG 0x00 16. "   ADC3_DLLEN_2      , ADC3 parameter of channel2. DLL enable, high effective, default 1" "0,1"
      BITFLD.LONG 0x00 15. "             Reserved           , Reserved" "Reserved,Reserved"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 14. "  Reserved       , Reserved" "Reserved,Reserved"
      BITFLD.LONG 0x00 8.--13. "  ADC3_DLLOOF_2      , ADC3 parameter of channel2. DLL offset input, default 0" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
      BITFLD.LONG 0x00 7. "  Reserved          , Reserved" "Reserved,Reserved"
      BITFLD.LONG 0x00 6. "      Reserved           , Reserved" "Reserved,Reserved"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 0.--5. "  ADC3_DLLIN_2   , ADC3 parameter of channel2. DLL INPUT, default 0" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
  GROUP.LONG 0x011C++0x3 "0x02070000 + 0x011C"
    LINE.LONG 0x00 "MDAR_ADC3_CTR12"
      BITFLD.LONG 0x00 31. "  Reserved       , Reserved" "Reserved,Reserved"
      BITFLD.LONG 0x00 30. "  ADC3_DIG_CLK_SEL_3 , ADC3 parameter of channel3.  digital clk Sel, default 0" "0,1"
      BITFLD.LONG 0x00 29. "   ADC3_VCM_SEL_3    , ADC3 parameter of channel3.  VCM Sel Signal, default 1 (low VCM voltage)" "0,1"
      BITFLD.LONG 0x00 27.--28. "             ADC3_DELAY_CAP_3   , ADC3 parameter of channel3. delay cap sel, 0:high speed, default 10;" "high speed- default,1,2,3"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 25.--26. "  ADC3_BIT_SEL_3 , ADC3 parameter of channel3.  bit sel, default 0; 00:14 bits; 01 :13bits, 10:12 bits, 11:11bits" "1,1,2,3"
      BITFLD.LONG 0x00 23.--24. "         ADC3_VREF_SEL_3    , ADC3 parameter of channel3. Vref sel; default 2;" "0,1,2,3"
      BITFLD.LONG 0x00 21.--22. "   ADC3_VREF_BOOST_3 , ADC3 parameter of channel3. vref boost speed, default 11; 00:min current, 11:max current" "min current-,1,2,3"
      BITFLD.LONG 0x00 19.--20. "  ADC3_QUANT_BOOST_3 , ADC3 parameter of channel3. quant boost speed, default 11;  00: min current; 11:max current" "min current;,1,2,3"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 18. "  ADC3_DLLRD_3   , ADC3 parameter of channel3. DLL read enable, high effective, default 0" "0,1"
      BITFLD.LONG 0x00 17. "         ADC3_DLLWR_3       , ADC3 parameter of channel3. DLL write enable, high effective, default 0" "0,1"
      BITFLD.LONG 0x00 16. "   ADC3_DLLEN_3      , ADC3 parameter of channel3. DLL enable, high effective, default 1" "0,1"
      BITFLD.LONG 0x00 15. "             Reserved           , Reserved" "Reserved,Reserved"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 14. "  Reserved       , Reserved" "Reserved,Reserved"
      BITFLD.LONG 0x00 8.--13. "  ADC3_DLLOOF_3      , ADC3 parameter of channel3. DLL offset input, default 0" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
      BITFLD.LONG 0x00 7. "  Reserved          , Reserved" "Reserved,Reserved"
      BITFLD.LONG 0x00 6. "      Reserved           , Reserved" "Reserved,Reserved"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 0.--5. "  ADC3_DLLIN_3   , ADC3 parameter of channel3. DLL INPUT, default 0" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
  GROUP.LONG 0x0120++0x3 "0x02070000 + 0x0120"
    LINE.LONG 0x00 "MDAR_ADC3_CTR20"
      BITFLD.LONG 0x00 16.--31. "  ADC3_RSV_5 , Reserved" "none"
      BITFLD.LONG 0x00 0.--15. "  ADC3_RSV_4 , Reserved" "none"
  GROUP.LONG 0x0124++0x3 "0x02070000 + 0x0124"
    LINE.LONG 0x00 "MDAR_ADC3_CTR21"
      BITFLD.LONG 0x00 31. "  Reserved       , Reserved" "Reserved,Reserved"
      BITFLD.LONG 0x00 30. "  ADC3_DIG_CLK_SEL_4 , ADC3 parameter of channel4.  digital clk Sel, default 0" "0,1"
      BITFLD.LONG 0x00 29. "   ADC3_VCM_SEL_4    , ADC3 parameter of channel4.  VCM Sel Signal, default 1 (low VCM voltage)" "0,1"
      BITFLD.LONG 0x00 27.--28. "             ADC3_DELAY_CAP_4   , ADC3 parameter of channel4. delay cap sel, 0:high speed, default 10;" "high speed- default,1,2,3"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 25.--26. "  ADC3_BIT_SEL_4 , ADC3 parameter of channel4.  bit sel, default 0; 00:14 bits; 01 :13bits, 10:12 bits, 11:11bits" "1,1,2,3"
      BITFLD.LONG 0x00 23.--24. "         ADC3_VREF_SEL_4    , ADC3 parameter of channel4. Vref sel; default 2;" "0,1,2,3"
      BITFLD.LONG 0x00 21.--22. "   ADC3_VREF_BOOST_4 , ADC3 parameter of channel4. vref boost speed, default 11; 00:min current, 11:max current" "min current-,1,2,3"
      BITFLD.LONG 0x00 19.--20. "  ADC3_QUANT_BOOST_4 , ADC3 parameter of channel4. quant boost speed, default 11;  00: min current; 11:max current" "min current;,1,2,3"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 18. "  ADC3_DLLRD_4   , ADC3 parameter of channel4. DLL read enable, high effective, default 0" "0,1"
      BITFLD.LONG 0x00 17. "         ADC3_DLLWR_4       , ADC3 parameter of channel4. DLL write enable, high effective, default 0" "0,1"
      BITFLD.LONG 0x00 16. "   ADC3_DLLEN_4      , ADC3 parameter of channel4. DLL enable, high effective, default 1" "0,1"
      BITFLD.LONG 0x00 15. "             Reserved           , Reserved" "Reserved,Reserved"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 14. "  Reserved       , Reserved" "Reserved,Reserved"
      BITFLD.LONG 0x00 8.--13. "  ADC3_DLLOOF_4      , ADC3 parameter of channel4. DLL offset input, default 0" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
      BITFLD.LONG 0x00 7. "  Reserved          , Reserved" "Reserved,Reserved"
      BITFLD.LONG 0x00 6. "      Reserved           , Reserved" "Reserved,Reserved"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 0.--5. "  ADC3_DLLIN_4   , ADC3 parameter of channel4. DLL INPUT, default 0" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
  GROUP.LONG 0x0128++0x3 "0x02070000 + 0x0128"
    LINE.LONG 0x00 "MDAR_ADC3_CTR22"
      BITFLD.LONG 0x00 31. "  Reserved       , Reserved" "Reserved,Reserved"
      BITFLD.LONG 0x00 30. "  ADC3_DIG_CLK_SEL_5 , ADC3 parameter of channel5.  digital clk Sel, default 0" "0,1"
      BITFLD.LONG 0x00 29. "   ADC3_VCM_SEL_5    , ADC3 parameter of channel5.  VCM Sel Signal, default 1 (low VCM voltage)" "0,1"
      BITFLD.LONG 0x00 27.--28. "             ADC3_DELAY_CAP_5   , ADC3 parameter of channel5. delay cap sel, 0:high speed, default 10;" "high speed- default,1,2,3"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 25.--26. "  ADC3_BIT_SEL_5 , ADC3 parameter of channel5.  bit sel, default 0; 00:14 bits; 01 :13bits, 10:12 bits, 11:11bits" "1,1,2,3"
      BITFLD.LONG 0x00 23.--24. "         ADC3_VREF_SEL_5    , ADC3 parameter of channel5. Vref sel; default 2;" "0,1,2,3"
      BITFLD.LONG 0x00 21.--22. "   ADC3_VREF_BOOST_5 , ADC3 parameter of channel5. vref boost speed, default 11; 00:min current, 11:max current" "min current-,1,2,3"
      BITFLD.LONG 0x00 19.--20. "  ADC3_QUANT_BOOST_5 , ADC3 parameter of channel5. quant boost speed, default 11;  00: min current; 11:max current" "min current;,1,2,3"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 18. "  ADC3_DLLRD_5   , ADC3 parameter of channel5. DLL read enable, high effective, default 0" "0,1"
      BITFLD.LONG 0x00 17. "         ADC3_DLLWR_5       , ADC3 parameter of channel5. DLL write enable, high effective, default 0" "0,1"
      BITFLD.LONG 0x00 16. "   ADC3_DLLEN_5      , ADC3 parameter of channel5. DLL enable, high effective, default 1" "0,1"
      BITFLD.LONG 0x00 15. "             Reserved           , Reserved" "Reserved,Reserved"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 14. "  Reserved       , Reserved" "Reserved,Reserved"
      BITFLD.LONG 0x00 8.--13. "  ADC3_DLLOOF_5      , ADC3 parameter of channel5. DLL offset input, default 0" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
      BITFLD.LONG 0x00 7. "  Reserved          , Reserved" "Reserved,Reserved"
      BITFLD.LONG 0x00 6. "      Reserved           , Reserved" "Reserved,Reserved"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 0.--5. "  ADC3_DLLIN_5   , ADC3 parameter of channel5. DLL INPUT, default 0" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
  GROUP.LONG 0x012C++0x3 "0x02070000 + 0x012C"
    LINE.LONG 0x00 "MDAR_AFCDAC1_CFG"
      BITFLD.LONG 0x00 31. "  Reserved              , Reserved" "Reserved,Reserved"
      BITFLD.LONG 0x00 28.--30. "  AFCDAC1_CHANNEL_MASK , enable the  AFCDAC1 channels when the rfctrl15_xx is active. active high.[28] for lte subsystem; [29] for tg subsystem; [30] for wg subsystem." "0,1,2,3,4,5,6,7"
      BITFLD.LONG 0x00 27. "         Reserved           , Reserved" "Reserved,Reserved"
      BITFLD.LONG 0x00 24.--26. "  AFCDAC1_CHANNEL_SSET , software set the AFCDAC1 channels active or not, active high.[24] for lte subsystem; [25] for tg subsystem; [26] for wg subsystem." "0,1,2,3,4,5,6,7"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 23. "  AFCDAC1_LOW_V_CON_SST , Reserved" "0,1"
      BITFLD.LONG 0x00 21.--22. "         Reserved             , Reserved" "Reserved,Reserved,Reserved,Reserved"
      BITFLD.LONG 0x00 20. "  AFCDAC1_BP_RES_SST , When none of the channel is active, these bits will be applied to AFCDAC1, can also be seen as the default parameters of AFCDAC1" "0,1"
      BITFLD.LONG 0x00 18.--19. "         AFCDAC1_G_SST        , When none of the channel is active, these bits will be applied to AFCDAC1, can also be seen as the default parameters of AFCDAC1" "0,1,2,3"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 16.--17. "  AFCDAC1_CTL_SST       , When none of the channel is active, these bits will be applied to AFCDAC1, can also be seen as the default parameters of AFCDAC1" "0,1,2,3"
      BITFLD.LONG 0x00 15. "         AFCDAC1_PD_SST       , When none of the channel is active, these bits will be applied to AFCDAC1, can also be seen as the default parameters of AFCDAC1" "0,1"
      BITFLD.LONG 0x00 14. "         Reserved           , Reserved" "Reserved,Reserved"
      BITFLD.LONG 0x00 0.--13. "  AFCDAC1_D_SST        , When none of the channel is active, these bits will be applied to AFCDAC1, can also be seen as the default parameters of AFCDAC1" "none"
      TEXTLINE "                           "
  GROUP.LONG 0x0130++0x3 "0x02070000 + 0x0130"
    LINE.LONG 0x00 "MDAR_AFCDAC2_CFG"
      BITFLD.LONG 0x00 31. "  Reserved              , Reserved" "Reserved,Reserved"
      BITFLD.LONG 0x00 28.--30. "  AFCDAC2_CHANNEL_MASK , enable the  AFCDAC2 channels when the rfctrl15_xx is active. active high.[28] for lte subsystem; [29] for tg subsystem; [30] for wg subsystem." "0,1,2,3,4,5,6,7"
      BITFLD.LONG 0x00 27. "         Reserved           , Reserved" "Reserved,Reserved"
      BITFLD.LONG 0x00 24.--26. "  AFCDAC2_CHANNEL_SSET , software set the AFCDAC2 channels active or not, active high.[24] for lte subsystem; [25] for tg subsystem; [26] for wg subsystem." "0,1,2,3,4,5,6,7"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 23. "  AFCDAC2_LOW_V_CON_SST , Reserved" "0,1"
      BITFLD.LONG 0x00 21.--22. "         Reserved             , Reserved" "Reserved,Reserved,Reserved,Reserved"
      BITFLD.LONG 0x00 20. "  AFCDAC2_BP_RES_SST , When none of the channel is active, these bits will be applied to AFCDAC2, can also be seen as the default parameters of AFCDAC2" "0,1"
      BITFLD.LONG 0x00 18.--19. "         AFCDAC2_G_SST        , When none of the channel is active, these bits will be applied to AFCDAC2, can also be seen as the default parameters of AFCDAC2" "0,1,2,3"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 16.--17. "  AFCDAC2_CTL_SST       , When none of the channel is active, these bits will be applied to AFCDAC2, can also be seen as the default parameters of AFCDAC2" "0,1,2,3"
      BITFLD.LONG 0x00 15. "         AFCDAC2_PD_SST       , When none of the channel is active, these bits will be applied to AFCDAC2, can also be seen as the default parameters of AFCDAC2" "0,1"
      BITFLD.LONG 0x00 14. "         Reserved           , Reserved" "Reserved,Reserved"
      BITFLD.LONG 0x00 0.--13. "  AFCDAC2_D_SST        , When none of the channel is active, these bits will be applied to AFCDAC2, can also be seen as the default parameters of AFCDAC2" "none"
      TEXTLINE "                           "
  GROUP.LONG 0x0134++0x3 "0x02070000 + 0x0134"
    LINE.LONG 0x00 "MDAR_APCDAC1_CFG"
      BITFLD.LONG 0x00 31. "  Reserved              , Reserved" "Reserved,Reserved"
      BITFLD.LONG 0x00 28.--30. "  APCDAC1_CHANNEL_MASK , enable the  APCDAC1 channels when the rfctrl15_xx is active. active high.[28] for lte subsystem; [29] for tg subsystem; [30] for wg subsystem." "0,1,2,3,4,5,6,7"
      BITFLD.LONG 0x00 27. "  Reserved           , Reserved" "Reserved,Reserved"
      BITFLD.LONG 0x00 24.--26. "  APCDAC1_CHANNEL_SSET , software set the APCDAC1 channels active or not, active high.[24] for lte subsystem; [25] for tg subsystem; [26] for wg subsystem." "0,1,2,3,4,5,6,7"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 23. "  APCDAC1_LOW_V_CON_SST , Reserved" "0,1"
      BITFLD.LONG 0x00 21.--22. "         APCDAC1_OUTSEL_SST   , Reserved" "0,1,2,3"
      BITFLD.LONG 0x00 20. "  APCDAC1_BP_RES_SST , When none of the channel is active, these bits will be applied to APCDAC1, can also be seen as the default parameters of APCDAC1" "0,1"
      BITFLD.LONG 0x00 18.--19. "         APCDAC1_G_SST        , When none of the channel is active, these bits will be applied to APCDAC1, can also be seen as the default parameters of APCDAC1" "0,1,2,3"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 16.--17. "  APCDAC1_CTL_SST       , When none of the channel is active, these bits will be applied to APCDAC1, can also be seen as the default parameters of APCDAC1" "0,1,2,3"
      BITFLD.LONG 0x00 15. "         APCDAC1_PD_SST       , When none of the channel is active, these bits will be applied to APCDAC1, can also be seen as the default parameters of APCDAC1" "0,1"
      BITFLD.LONG 0x00 14. "  APCDAC1_SEL_SST    , When none of the channel is active, these bits will be applied to APCDAC1, can also be seen as the default parameters of APCDAC1" "0,1"
      BITFLD.LONG 0x00 0.--13. "         APCDAC1_D_SST        , When none of the channel is active, these bits will be applied to APCDAC1, can also be seen as the default parameters of APCDAC1" "none"
      TEXTLINE "                           "
  GROUP.LONG 0x0138++0x3 "0x02070000 + 0x0138"
    LINE.LONG 0x00 "MDAR_APCDAC2_CFG"
      BITFLD.LONG 0x00 31. "  Reserved              , Reserved" "Reserved,Reserved"
      BITFLD.LONG 0x00 28.--30. "  APCDAC2_CHANNEL_MASK , enable the  APCDAC2 channels when the rfctrl15_xx is active. active high.[28] for lte subsystem; [29] for tg subsystem; [30] for wg subsystem." "0,1,2,3,4,5,6,7"
      BITFLD.LONG 0x00 27. "  Reserved           , Reserved" "Reserved,Reserved"
      BITFLD.LONG 0x00 24.--26. "  APCDAC2_CHANNEL_SSET , software set the APCDAC2 channels active or not, active high.[24] for lte subsystem; [25] for tg subsystem; [26] for wg subsystem." "0,1,2,3,4,5,6,7"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 23. "  APCDAC2_LOW_V_CON_SST , Reserved" "0,1"
      BITFLD.LONG 0x00 21.--22. "         APCDAC2_OUTSEL_SST   , Reserved" "0,1,2,3"
      BITFLD.LONG 0x00 20. "  APCDAC2_BP_RES_SST , When none of the channel is active, these bits will be applied to APCDAC2, can also be seen as the default parameters of APCDAC2" "0,1"
      BITFLD.LONG 0x00 18.--19. "         APCDAC2_G_SST        , When none of the channel is active, these bits will be applied to APCDAC2, can also be seen as the default parameters of APCDAC2" "0,1,2,3"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 16.--17. "  APCDAC2_CTL_SST       , When none of the channel is active, these bits will be applied to APCDAC2, can also be seen as the default parameters of APCDAC2" "0,1,2,3"
      BITFLD.LONG 0x00 15. "         APCDAC2_PD_SST       , When none of the channel is active, these bits will be applied to APCDAC2, can also be seen as the default parameters of APCDAC2" "0,1"
      BITFLD.LONG 0x00 14. "  APCDAC2_SEL_SST    , When none of the channel is active, these bits will be applied to APCDAC2, can also be seen as the default parameters of APCDAC2" "0,1"
      BITFLD.LONG 0x00 0.--13. "         APCDAC2_D_SST        , When none of the channel is active, these bits will be applied to APCDAC2, can also be seen as the default parameters of APCDAC2" "none"
      TEXTLINE "                           "
  GROUP.LONG 0x13C++0x3 "0x02070000 + 0x13C"
    LINE.LONG 0x00 "MDAR_RFSPI_CFG"
      BITFLD.LONG 0x00 29.--31. "  RFSBI2_CHANNEL_MASK , enable the  RFSBI2 BUS channels when the rfctrl15_xx is active. active high.[29] for lte subsystem; [30] for tg subsystem; [31] for wg subsystem." "0,1,2,3,4,5,6,7"
      BITFLD.LONG 0x00 26.--28. "  RFSBI2_CHANNEL_SSET , software set the RFSBI2 BUS channels active or not, active high.[26] for lte subsystem; [27] for tg subsystem; [28] for wg subsystem." "0,1,2,3,4,5,6,7"
      BITFLD.LONG 0x00 25. "  RFSBI2_IDATA_SST , When none of the channel is active, this bit will be applied to RFSBI2 interface, can also be seen as the default parameters of RFSBI2" "0,1"
      BITFLD.LONG 0x00 24. "  RFSBI2_ODATA_SST  , When none of the channel is active, this bit will be applied to RFSBI2 interface, can also be seen as the default parameters of RFSBI2" "0,1"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 23. "  RFSBI2_DATA_OE_SST  , When none of the channel is active, this bit will be applied to RFSBI2 interface, can also be seen as the default parameters of RFSBI2" "0,1"
      BITFLD.LONG 0x00 22. "  RFSBI2_DATA_IE_SST  , When none of the channel is active, this bit will be applied to RFSBI2 interface, can also be seen as the default parameters of RFSBI2" "0,1"
      BITFLD.LONG 0x00 21. "  RFSBI2_CLK_SST   , When none of the channel is active, this bit will be applied to RFSBI2 interface, can also be seen as the default parameters of RFSBI2" "0,1"
      BITFLD.LONG 0x00 20. "  RFSBI2_CLK_OE_SST , When none of the channel is active, this bit will be applied to RFSBI2 interface, can also be seen as the default parameters of RFSBI2" "0,1"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 19. "  RFSBI2_EN0_SST      , When none of the channel is active, this bit will be applied to RFSBI2 interface, can also be seen as the default parameters of RFSBI2" "0,1"
      BITFLD.LONG 0x00 18. "  RFSBI2_EN0_OE_SST   , When none of the channel is active, this bit will be applied to RFSBI2 interface, can also be seen as the default parameters of RFSBI2" "0,1"
      BITFLD.LONG 0x00 17. "  RFSBI2_EN1_SST   , When none of the channel is active, this bit will be applied to RFSBI2 interface, can also be seen as the default parameters of RFSBI2" "0,1"
      BITFLD.LONG 0x00 16. "  RFSBI2_EN1_OE_SST , When none of the channel is active, this bit will be applied to RFSBI2 interface, can also be seen as the default parameters of RFSBI2" "0,1"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 13.--15. "  RFSBI1_CHANNEL_MASK , enable the  RFSBI1 BUS channels when the rfctrl15_xx is active. active high.[13] for lte subsystem; [14] for tg subsystem; [15] for wg subsystem." "0,1,2,3,4,5,6,7"
      BITFLD.LONG 0x00 10.--12. "  RFSBI1_CHANNEL_SSET , software set the RFSBI1 BUS channels active or not, active high.[10] for lte subsystem; [11] for tg subsystem; [12] for wg subsystem." "0,1,2,3,4,5,6,7"
      BITFLD.LONG 0x00 9. "  RFSBI1_IDATA_SST , When none of the channel is active, this bit will be applied to RFSBI1 interface, can also be seen as the default parameters of RFSBI1" "0,1"
      BITFLD.LONG 0x00 8. "  RFSBI1_ODATA_SST  , When none of the channel is active, this bit will be applied to RFSBI1 interface, can also be seen as the default parameters of RFSBI1" "0,1"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 7. "  RFSBI1_DATA_OE_SST  , When none of the channel is active, this bit will be applied to RFSBI1 interface, can also be seen as the default parameters of RFSBI1" "0,1"
      BITFLD.LONG 0x00 6. "  RFSBI1_DATA_IE_SST  , When none of the channel is active, this bit will be applied to RFSBI1 interface, can also be seen as the default parameters of RFSBI1" "0,1"
      BITFLD.LONG 0x00 5. "  RFSBI1_CLK_SST   , When none of the channel is active, this bit will be applied to RFSBI1 interface, can also be seen as the default parameters of RFSBI1" "0,1"
      BITFLD.LONG 0x00 4. "  RFSBI1_CLK_OE_SST , When none of the channel is active, this bit will be applied to RFSBI1 interface, can also be seen as the default parameters of RFSBI1" "0,1"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 3. "  RFSBI1_EN0_SST      , When none of the channel is active, this bit will be applied to RFSBI1 interface, can also be seen as the default parameters of RFSBI1" "0,1"
      BITFLD.LONG 0x00 2. "  RFSBI1_EN0_OE_SST   , When none of the channel is active, this bit will be applied to RFSBI1 interface, can also be seen as the default parameters of RFSBI1" "0,1"
      BITFLD.LONG 0x00 1. "  RFSBI1_EN1_SST   , When none of the channel is active, this bit will be applied to RFSBI1 interface, can also be seen as the default parameters of RFSBI1" "0,1"
      BITFLD.LONG 0x00 0. "  RFSBI1_EN1_OE_SST , When none of the channel is active, this bit will be applied to RFSBI1 interface, can also be seen as the default parameters of RFSBI1" "0,1"
      TEXTLINE "                           "
  GROUP.LONG 0x140++0x3 "0x02070000 + 0x140"
    LINE.LONG 0x00 "MDAR_RFMIPI_CFG"
      BITFLD.LONG 0x00 31. "  Reserved               , Reserved" "Reserved,Reserved"
      BITFLD.LONG 0x00 28.--30. "  RFMIPI2_CHANNEL_MASK  , enable the  RFMIPI2 BUS channels when the rfctrl15_xx is active. active high.[28] for lte subsystem; [29] for tg subsystem; [30] for wg subsystem." "0,1,2,3,4,5,6,7"
      BITFLD.LONG 0x00 27. "  Reserved               , Reserved" "Reserved,Reserved"
      BITFLD.LONG 0x00 24.--26. "  RFMIPI2_CHANNEL_SSET  , software set the RFMIPI2 BUS channels active or not, active high.[24] for lte subsystem; [25] for tg subsystem; [26] for wg subsystem." "0,1,2,3,4,5,6,7"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 21.--23. "  Reserved               , Reserved" "Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved"
      BITFLD.LONG 0x00 20. "  PAD_OUT_RFFE2_CLK_SST , When none of the channel is active, this bit will be applied to RFMIPI2 interface, can also be seen as the default parameters of RFMIPI2." "0,1"
      BITFLD.LONG 0x00 19. "  PAD_OUT_RFFE2_DATA_SST , When none of the channel is active, this bit will be applied to RFMIPI2 interface, can also be seen as the default parameters of RFMIPI2." "0,1"
      BITFLD.LONG 0x00 18. "         PAD_IN_RFFE2_DATA_SST , When none of the channel is active, this bit will be applied to RFMIPI2 interface, can also be seen as the default parameters of RFMIPI2." "0,1"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 17. "  PAD_OE_RFFE2_DATA_SST  , When none of the channel is active, this bit will be applied to RFMIPI2 interface, can also be seen as the default parameters of RFMIPI2." "0,1"
      BITFLD.LONG 0x00 16. "         PAD_IE_RFFE2_DATA_SST , When none of the channel is active, this bit will be applied to RFMIPI2 interface, can also be seen as the default parameters of RFMIPI2." "0,1"
      BITFLD.LONG 0x00 15. "  Reserved               , Reserved" "Reserved,Reserved"
      BITFLD.LONG 0x00 12.--14. "  RFMIPI1_CHANNEL_MASK  , enable the  RFMIPI1 BUS channels when the rfctrl15_xx is active. active high.[12] for lte subsystem; [13] for tg subsystem; [14] for wg subsystem." "0,1,2,3,4,5,6,7"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 11. "  Reserved               , Reserved" "Reserved,Reserved"
      BITFLD.LONG 0x00 8.--10. "  RFMIPI1_CHANNEL_SSET  , software set the RFMIPI1 BUS channels active or not, active high.[8] for lte subsystem; [9] for tg subsystem; [10] for wg subsystem." "0,1,2,3,4,5,6,7"
      BITFLD.LONG 0x00 5.--7. "  Reserved               , Reserved" "Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved"
      BITFLD.LONG 0x00 4. "  PAD_OUT_RFFE1_CLK_SST , When none of the channel is active, this bit will be applied to RFMIPI1 interface, can also be seen as the default parameters of RFMIPI1." "0,1"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 3. "  PAD_OUT_RFFE1_DATA_SST , When none of the channel is active, this bit will be applied to RFMIPI1 interface, can also be seen as the default parameters of RFMIPI1." "0,1"
      BITFLD.LONG 0x00 2. "         PAD_IN_RFFE1_DATA_SST , When none of the channel is active, this bit will be applied to RFMIPI1 interface, can also be seen as the default parameters of RFMIPI1." "0,1"
      BITFLD.LONG 0x00 1. "  PAD_OE_RFFE1_DATA_SST  , When none of the channel is active, this bit will be applied to RFMIPI1 interface, can also be seen as the default parameters of RFMIPI1." "0,1"
      BITFLD.LONG 0x00 0. "         PAD_IE_RFFE1_DATA_SST , When none of the channel is active, this bit will be applied to RFMIPI1 interface, can also be seen as the default parameters of RFMIPI1." "0,1"
      TEXTLINE "                           "
  GROUP.LONG 0x144++0x3 "0x02070000 + 0x144"
    LINE.LONG 0x00 "MDAR_APCDAC_OUTSEL"
      BITFLD.LONG 0x00 31. "  AFCDAC_LOW_V_CON_GGE , " "0,1"
      BITFLD.LONG 0x00 30. "  AFCDAC_LOW_V_CON_WG  , " "0,1"
      BITFLD.LONG 0x00 29. "  AFCDAC_LOW_V_CON_WD  , " "0,1"
      BITFLD.LONG 0x00 28. "  AFCDAC_LOW_V_CON_TG  , " "0,1"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 27. "  AFCDAC_LOW_V_CON_TD  , " "0,1"
      BITFLD.LONG 0x00 26. "  AFCDAC_LOW_V_CON_LTE , " "0,1"
      BITFLD.LONG 0x00 24.--25. "  APCDACX_G3_SST       , " "0,1,2,3"
      BITFLD.LONG 0x00 22.--23. "  APCDACX_G2_SST       , " "0,1,2,3"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 20.--21. "  APCDACX_G1_SST       , " "0,1,2,3"
      BITFLD.LONG 0x00 18.--19. "  APCDACX_G0_SST       , " "0,1,2,3"
      BITFLD.LONG 0x00 17. "  APCDAC_LOW_V_CON_GGE , " "0,1"
      BITFLD.LONG 0x00 16. "  APCDAC_LOW_V_CON_WG  , " "0,1"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 15. "  APCDAC_LOW_V_CON_WD  , " "0,1"
      BITFLD.LONG 0x00 14. "  APCDAC_LOW_V_CON_TG  , " "0,1"
      BITFLD.LONG 0x00 13. "  APCDAC_LOW_V_CON_TD  , " "0,1"
      BITFLD.LONG 0x00 12. "  APCDAC_LOW_V_CON_LTE , " "0,1"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 10.--11. "  APCDAC_OUTSEL_GGE    , The APCDACX mapping function of the GSM  subsystem." "0,1,2,3"
      BITFLD.LONG 0x00 8.--9. "  APCDAC_OUTSEL_WG     , The APCDACX mapping function of the GSM in WG subsystem." "0,1,2,3"
      BITFLD.LONG 0x00 6.--7. "  APCDAC_OUTSEL_WD     , The APCDACX mapping function of the WCDMA in WG subsystem." "0,1,2,3"
      BITFLD.LONG 0x00 4.--5. "  APCDAC_OUTSEL_TG     , The APCDACX mapping function of the GSM in TG subsystem." "0,1,2,3"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 2.--3. "  APCDAC_OUTSEL_TD     , The APCDACX mapping function of the TDSCDMA in TG subsystem." "0,1,2,3"
      BITFLD.LONG 0x00 0.--1. "  APCDAC_OUTSEL_LTE    , The APCDACX mapping function of the LTE subsystem." "0,1,2,3"
  GROUP.LONG 0x148++0x3 "0x02070000 + 0x148"
    LINE.LONG 0x00 "MDAR_CLASH_CHK"
      BITFLD.LONG 0x00 30.--31. "  Reserved                   , Reserved." "Reserved,Reserved,Reserved,Reserved"
      BITFLD.LONG 0x00 29. "                                      RFSBI2_CLASH_CHK_INTRP_EN     , Enable to clash detection of the RFSBI2 channel requests. Active high." "0,1"
      BITFLD.LONG 0x00 28. "       RFSBI1_CLASH_CHK_INTRP_EN    , Enable to clash detection of the RFSBI1 channel requests. Active high." "0,1"
      BITFLD.LONG 0x00 27. "         RFMIPI2_CLASH_CHK_INTRP_EN , Enable to clash detection of the RFMIPI2 channel requests. Active high." "0,1"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 26. "  RFMIPI1_CLASH_CHK_INTRP_EN , Enable to clash detection of the RFMIPI1 channel requests. Active high." "0,1"
      BITFLD.LONG 0x00 25. "                                             APCDAC2_CLASH_CHK_INTRP_EN    , Enable to clash detection of the APCDAC2 channel requests. Active high." "0,1"
      BITFLD.LONG 0x00 24. "       APCDAC1_CLASH_CHK_INTRP_EN   , Enable to clash detection of the APCDAC1 channel requests. Active high." "0,1"
      BITFLD.LONG 0x00 23. "         AFCDAC2_CLASH_CHK_INTRP_EN , Enable to clash detection of the AFCDAC2 channel requests. Active high." "0,1"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 22. "  AFCDAC1_CLASH_CHK_INTRP_EN , Enable to clash detection of the AFCDAC1 channel requests. Active high." "0,1"
      BITFLD.LONG 0x00 21. "                                             ADA3_TX_CLASH_CHK_INTRP_EN    , Enable to clash detection of the DAC3 channel requests. Active high." "0,1"
      BITFLD.LONG 0x00 20. "       ADA3_RX_CLASH_CHK_INTRP_EN   , Enable to clash detection of the ADC3 channel requests. Active high." "0,1"
      BITFLD.LONG 0x00 19. "         ADA2_TX_CLASH_CHK_INTRP_EN , Enable to clash detection of the DAC2 channel requests. Active high." "0,1"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 18. "  ADA2_RX_CLASH_CHK_INTRP_EN , Enable to clash detection of the ADC2 channel requests. Active high." "0,1"
      BITFLD.LONG 0x00 17. "                                             ADA1_TX_CLASH_CHK_INTRP_EN    , Enable to clash detection of the DAC1 channel requests. Active high." "0,1"
      BITFLD.LONG 0x00 16. "       ADA1_RX_CLASH_CHK_INTRP_EN   , Enable to clash detection of the ADC1 channel requests. Active high." "0,1"
      BITFLD.LONG 0x00 9.--15. "         Reserved                   , Reserved" "Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 8. "  CHK_CLASH_STFREE           , Whenever a clash have been detected, write 1 to this bit, so that reset the MDAR_CLASH_SNAP, MDAR_CLASH_STATUS1,MDAR_CLASH_STATUS2,MDAR_CLASH_STATUS3. This bit is self cleared." "0,1"
      BITFLD.LONG 0x00 7. "                                             CHK_CLASH_CLR                 , Whenever a clash have been detected, write 1 to this bit, so that a new detection can run. This bit is self cleared." "0,1"
      BITFLD.LONG 0x00 5.--6. "       Reserved                     , Reserved" "Reserved,Reserved,Reserved,Reserved"
      BITFLD.LONG 0x00 4. "  CHK_CLASH_RTC_SNAP_MODE    , 0: use the shadow function to sync the RTC;1:Use the clock edge to sync the RTC" "use the shadow function to sync the RTC;,Use the clock edge to sync the RTC"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 3. "  CHK_CLASH_RTC_SNAP_EDGE    , This function based on the CHK_CLASH_SNAP_MODE is high.0: the snap happened at the negedge of the clk_32k;1: the snap happened at the posedge of the clk_32k;" "the snap happened at the negedge of the clk_,the snap happened at the posedge of the clk_"
      BITFLD.LONG 0x00 2. "  CHK_CLASH_RTC_SNAP_INTRP_TYPE , The interruption type of the clash. 1: level;0:pulse" "pulse,level;"
      BITFLD.LONG 0x00 1. "  CHK_CLASH_RTC_SNAP_INTRP_CLR , Write 1 to this bit will clear the interruption of the clash in the mdar_top module. This bit is self cleared." "0,1"
      BITFLD.LONG 0x00 0. "         CHK_CLASH_RTC_SNAP_INTRP   , 1: there is a clash have been happened. 0: there is none clash have been happened." "there is none clash have been happened.,there is a clash have been happened."
      TEXTLINE "                           "
  GROUP.LONG 0x14C++0x3 "0x02070000 + 0x14C"
    LINE.LONG 0x00 "MDAR_CLASH_SNAP"
  GROUP.LONG 0x150++0x3 "0x02070000 + 0x150"
    LINE.LONG 0x00 "MDAR_CLASH_STATUS1"
      BITFLD.LONG 0x00 30.--31. "  Reserved                      , Reserved" "Reserved,Reserved,Reserved,Reserved"
      BITFLD.LONG 0x00 25.--29. "  CHK_CLASH_ADA3_TX_CHANNEL_SEL , The channel access status of DAC3 when a clash happened." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
      BITFLD.LONG 0x00 20.--24. "  CHK_CLASH_ADA3_RX_CHANNEL_SEL , The channel access status of ADC3 when a clash happened." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
      BITFLD.LONG 0x00 15.--19. "  CHK_CLASH_ADA2_TX_CHANNEL_SEL , The channel access status of DAC2 when a clash happened." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 10.--14. "  CHK_CLASH_ADA2_RX_CHANNEL_SEL , The channel access status of ADC2 when a clash happened." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
      BITFLD.LONG 0x00 5.--9. "        CHK_CLASH_ADA1_TX_CHANNEL_SEL , The channel access status of  DAC1 when a clash happened." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
      BITFLD.LONG 0x00 0.--4. "  CHK_CLASH_ADA1_RX_CHANNEL_SEL , The channel access status of ADC1 when a clash happened." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
  GROUP.LONG 0x154++0x3 "0x02070000 + 0x154"
    LINE.LONG 0x00 "MDAR_CLASH_STATUS2"
      BITFLD.LONG 0x00 11.--13. "  CHK_CLASH_APCDAC2_CHANNEL_SEL , The channel access status of APCDAC2 when a clash happened." "0,1,2,3,4,5,6,7"
      BITFLD.LONG 0x00 8.--10. "  CHK_CLASH_APCDAC1_CHANNEL_SEL , The channel access status of APCDAC1 when a clash happened." "0,1,2,3,4,5,6,7"
      BITFLD.LONG 0x00 6.--7. "  Reserved , Reserved." "Reserved,Reserved,Reserved,Reserved"
      BITFLD.LONG 0x00 3.--5. "  CHK_CLASH_AFCDAC2_CHANNEL_SEL , The channel access status of AFCDAC2 when a clash happened." "0,1,2,3,4,5,6,7"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 0.--2. "  CHK_CLASH_AFCDAC1_CHANNEL_SEL , The channel access status of AFCDAC1 when a clash happened." "0,1,2,3,4,5,6,7"
  GROUP.LONG 0x158++0x3 "0x02070000 + 0x158"
    LINE.LONG 0x00 "MDAR_CLASH_STATUS3"
      BITFLD.LONG 0x00 11.--13. "  CHK_CLASH_RFSBI2_CHANNEL_SEL  , The channel access status of RFSBI2 when a clash happened." "0,1,2,3,4,5,6,7"
      BITFLD.LONG 0x00 8.--10. "  CHK_CLASH_RFSBI1_CHANNEL_SEL , The channel access status of RFSBI1 when a clash happened." "0,1,2,3,4,5,6,7"
      BITFLD.LONG 0x00 6.--7. "  Reserved , Reserved." "Reserved,Reserved,Reserved,Reserved"
      BITFLD.LONG 0x00 3.--5. "  CHK_CLASH_RFMIPI2_CHANNEL_SEL , The channel access status of RFMIPI2 when a clash happened." "0,1,2,3,4,5,6,7"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 0.--2. "  CHK_CLASH_RFMIPI1_CHANNEL_SEL , The channel access status of RFMIPI1 when a clash happened." "0,1,2,3,4,5,6,7"
  GROUP.LONG 0x160++0x3 "0x02070000 + 0x160"
    LINE.LONG 0x00 "MDAR_EXTRA_CFG0"
      BITFLD.LONG 0x00 24.--31. "  APT_DCM2_EXTRA_CFG    , For future use" "none"
      BITFLD.LONG 0x00 23. "   APT_DCM2_ADI_EN       , Use the adi_mst hwx_tx_channel to transfer the mdar_apt_dcm2 signal" "0,1"
      BITFLD.LONG 0x00 20.--22. "  APT_DCM2_CHANNEL_SSET , Set the bit high will force high the request to APT_DCM2. bit[20] is for LTE, bit[22] is for WCDMA. Bit[21] is reserved, write 1 to this bit will lead fatal error." "0,1,2,3,4,5,6,7"
      BITFLD.LONG 0x00 19. "  APT_DCM2_SST          , If there is not any request from the 3 channel, this bit  determinate the output of the mdar_apt_dcm2 signal." "0,1"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 16.--18. "  APT_DCM2_CHANNEL_MASK , Set the bit high will enable the request to APT_DCM2" "0,1,2,3,4,5,6,7"
      BITFLD.LONG 0x00 8.--15. "  APT_DCM1_EXTRA_CFG    , For future use" "none"
      BITFLD.LONG 0x00 7. "   APT_DCM1_ADI_EN       , Use the adi_mst hwx_tx_channel to transfer the mdar_apt_dcm1 signal" "0,1"
      BITFLD.LONG 0x00 4.--6. "  APT_DCM1_CHANNEL_SSET , Set the bit high will force high the request to APT_dcm1. bit[4] is for LTE, bit[6] is for WCDMA. Bit[5] is reserved, write 1 to this bit will lead fatal error." "0,1,2,3,4,5,6,7"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 3. "  APT_DCM1_SST          , If there is not any request from the 3 channel, this bit  determinate the output of the mdar_apt_dcm1 signal." "0,1"
      BITFLD.LONG 0x00 0.--2. "  APT_DCM1_CHANNEL_MASK , Set the bit high will enable the request to APT_dcm1" "0,1,2,3,4,5,6,7"
  GROUP.LONG 0x164++0x3 "0x02070000 + 0x164"
    LINE.LONG 0x00 "MDAR_EXTRA_CFG1"
      BITFLD.LONG 0x00 10.--31. "  MDAR_EXTRA_CFG1      , For future use" "none"
      BITFLD.LONG 0x00 8.--9. "   MDAR_BB_LDO_REFCTRL  , Control LDO output voltage 00 – 1.717V     01 – 1.802V (default) 10 – 1.888V     11 – 1.971V" "0,1,2,3"
      BITFLD.LONG 0x00 7. "  Reserved , Reserved" "Reserved,Reserved"
      BITFLD.LONG 0x00 6. "  MDAR_BB_LDO_SLEEP_PD_EN , active high" "0,1"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 5. "  MDAR_BB_LDO_FORCE_ON , active high" "0,1"
      BITFLD.LONG 0x00 4. "  MDAR_BB_LDO_FORCE_PD , active high" "0,1"
      BITFLD.LONG 0x00 3. "  Reserved , Reserved" "Reserved,Reserved"
      BITFLD.LONG 0x00 2. "  MDAR_BB_BG_SLEEP_PD_EN  , active high" "0,1"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 1. "  MDAR_BB_BG_FORCE_ON  , active high" "0,1"
      BITFLD.LONG 0x00 0. "  MDAR_BB_BG_FORCE_PD  , active high" "0,1"
  GROUP.LONG 0x168++0x3 "0x02070000 + 0x168"
    LINE.LONG 0x00 "MDAR_RFCTRL15_INF0"
      BITFLD.LONG 0x00 20.--22. "  CHK_CLASH_RFCTRL15_CHX_SEL , The state of the three rfctrl15" "0,1,2,3,4,5,6,7"
      BITFLD.LONG 0x00 17.--19. "  Reserved , Reserved" "Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved"
      BITFLD.LONG 0x00 16. "  RFCTRL15_CHK_INTRP_EN , Enable to detection of the rfctrl15 channel requests. Active high." "0,1"
      BITFLD.LONG 0x00 13.--15. "  Reserved , Reserved" "Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 12. "  RFCTRL15_RTC_REFRESH       , Whenever a clash have been detected, write 1 to this bit, so that reset the MDAR_RFCTRL15_INF1, MDAR_RFCTRL15_INF2, MDAR_RFCTRL15_INF3, MDAR_RFCTRL15_INF4, MDAR_RFCTRL15_INF5, MDAR_RFCTRL15_INF.This bit is self cleared." "0,1"
      BITFLD.LONG 0x00 9.--11. "  Reserved , Reserved" "Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved"
      BITFLD.LONG 0x00 8. "  RFCTRL15_SNAP_REFRESH , After find more than one rfctrl15, write 1 to this bit will refresh the rtc timer snapshot function." "0,1"
      BITFLD.LONG 0x00 7. "  Reserved , Reserved" "Reserved,Reserved"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 4.--6. "  RFCTRL15_SSET              , Set the bit high will force high the request to the rfctrl15-dectector. bit[4] is set for LTE subsystem; bit[5] is set for TG subsystem; bit[6] is set for WG subsystem" "0,1,2,3,4,5,6,7"
      BITFLD.LONG 0x00 3. "  Reserved , Reserved" "Reserved,Reserved"
      BITFLD.LONG 0x00 0.--2. "  RFCTRL15_MASK         , Set the bit high will enable high the request to the rfctrl15-dectector. bit[0] is set for LTE subsystem; bit[1] is set for TG subsystem; bit[2] is set for WG subsystem" "0,1,2,3,4,5,6,7"
  GROUP.LONG 0x16C++0x3 "0x02070000 + 0x16C"
    LINE.LONG 0x00 "MDAR_RFCTRL15_INF1"
  GROUP.LONG 0x170++0x3 "0x02070000 + 0x170"
    LINE.LONG 0x00 "MDAR_RFCTRL15_INF2"
  GROUP.LONG 0x174++0x3 "0x02070000 + 0x174"
    LINE.LONG 0x00 "MDAR_RFCTRL15_INF3"
  GROUP.LONG 0x178++0x3 "0x02070000 + 0x178"
    LINE.LONG 0x00 "MDAR_RFCTRL15_INF4"
  GROUP.LONG 0x17C++0x3 "0x02070000 + 0x17C"
    LINE.LONG 0x00 "MDAR_RFCTRL15_INF5"
  GROUP.LONG 0x180++0x3 "0x02070000 + 0x180"
    LINE.LONG 0x00 "MDAR_RFCTRL15_INF6"
  GROUP.LONG 0x0184++0x3 "0x02070000 + 0x0184"
    LINE.LONG 0x00 "MDAR_CFG4"
      BITFLD.LONG 0x00 30.--31. "  Reserved             , Reserved" "Reserved,Reserved,Reserved,Reserved"
      BITFLD.LONG 0x00 27.--29. "  RFCTRL_CHANNEL_MASK3 , Enable the uni_rfctl[3] channels when the rfctrl15_xx is active. Active high.[27] for lte subsystem; [28] for wtg subsystem; [29] for gge subsystem." "0,1,2,3,4,5,6,7"
      BITFLD.LONG 0x00 24.--26. "         RFCTRL_CHANNEL_MASK2 , Enable the uni_rfctl[2] channels when the rfctrl15_xx is active. Active high.[24] for lte subsystem; [25] for wtg subsystem; [26] for gge subsystem." "0,1,2,3,4,5,6,7"
      BITFLD.LONG 0x00 21.--23. "         RFCTRL_CHANNEL_MASK1 , Enable the uni_rfctl[1] channels when the rfctrl15_xx is active. Active high.[21] for lte subsystem; [22] for wtg subsystem; [23] for gge subsystem." "0,1,2,3,4,5,6,7"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 18.--20. "  RFCTRL_CHANNEL_MASK0 , Enable the uni_rfctl[0] channels when the rfctrl15_xx is active. Active high.[18] for lte subsystem; [19] for wtg subsystem; [20] for gge subsystem." "0,1,2,3,4,5,6,7"
      BITFLD.LONG 0x00 17. "         Reserved             , Reserved." "Reserved,Reserved"
      BITFLD.LONG 0x00 16. "  Reserved             , Reserved." "Reserved,Reserved"
      BITFLD.LONG 0x00 0.--15. "  RFCTRL150_SST        , The default value of the uni_rfctl[15:0] when no communication system get the control right of these pasd." "none"
      TEXTLINE "                           "
  GROUP.LONG 0x0188++0x3 "0x02070000 + 0x0188"
    LINE.LONG 0x00 "MDAR_CFG5"
      BITFLD.LONG 0x00 30.--31. "  Reserved              , Reserved." "Reserved,Reserved,Reserved,Reserved"
      BITFLD.LONG 0x00 27.--29. "  RFCTRL_CHANNEL_MASK13 , Enable the uni_rfctl[13] channels when the rfctrl15_xx is active. Active high.[27] for lte subsystem; [28] for wtg subsystem; [29] for gge subsystem." "0,1,2,3,4,5,6,7"
      BITFLD.LONG 0x00 24.--26. "  RFCTRL_CHANNEL_MASK12 , Enable the uni_rfctl[12] channels when the rfctrl15_xx is active. Active high.[24] for lte subsystem; [25] for wtg subsystem; [26] for gge subsystem." "0,1,2,3,4,5,6,7"
      BITFLD.LONG 0x00 21.--23. "  RFCTRL_CHANNEL_MASK11 , Enable the uni_rfctl[11] channels when the rfctrl15_xx is active. Active high.[21] for lte subsystem; [22] for wtg subsystem; [23] for gge subsystem." "0,1,2,3,4,5,6,7"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 18.--20. "  RFCTRL_CHANNEL_MASK10 , Enable the uni_rfctl[10] channels when the rfctrl15_xx is active. Active high.[18] for lte subsystem; [19] for wtg subsystem; [20] for gge subsystem." "0,1,2,3,4,5,6,7"
      BITFLD.LONG 0x00 15.--17. "         RFCTRL_CHANNEL_MASK9  , Enable the uni_rfctl[9] channels when the rfctrl15_xx is active. Active high.[15] for lte subsystem; [16] for wtg subsystem; [17] for gge subsystem." "0,1,2,3,4,5,6,7"
      BITFLD.LONG 0x00 12.--14. "  RFCTRL_CHANNEL_MASK8  , Enable the uni_rfctl[8] channels when the rfctrl15_xx is active. Active high.[12] for lte subsystem; [13] for wtg subsystem; [14] for gge subsystem." "0,1,2,3,4,5,6,7"
      BITFLD.LONG 0x00 9.--11. "  RFCTRL_CHANNEL_MASK7  , Enable the uni_rfctl[7] channels when the rfctrl15_xx is active. Active high.[9] for lte subsystem; [10] for wtg subsystem; [11] for gge subsystem." "0,1,2,3,4,5,6,7"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 6.--8. "  RFCTRL_CHANNEL_MASK6  , Enable the uni_rfctl[6] channels when the rfctrl15_xx is active. Active high.[6] for lte subsystem; [7] for wtg subsystem; [8] for gge subsystem." "0,1,2,3,4,5,6,7"
      BITFLD.LONG 0x00 3.--5. "         RFCTRL_CHANNEL_MASK5  , Enable the uni_rfctl[5] channels when the rfctrl15_xx is active. Active high.[3] for lte subsystem; [4] for wtg subsystem; [5] for gge subsystem." "0,1,2,3,4,5,6,7"
      BITFLD.LONG 0x00 0.--2. "  RFCTRL_CHANNEL_MASK4  , Enable the uni_rfctl[4] channels when the rfctrl15_xx is active. Active high.[0] for lte subsystem; [1] for wtg subsystem; [2] for gge subsystem." "0,1,2,3,4,5,6,7"
  GROUP.LONG 0x018C++0x3 "0x02070000 + 0x018C"
    LINE.LONG 0x00 "MDAR_CFG6"
      BITFLD.LONG 0x00 30.--31. "  Reserved             , Reserved." "Reserved,Reserved,Reserved,Reserved"
      BITFLD.LONG 0x00 27.--29. "  RFCTRL_CHANNEL_SSET7  , Software set the uni_rfctl[7] channels active or not, active high. [27] for lte subsystem; [28] for wtg subsystem; [29] for gge subsystem." "0,1,2,3,4,5,6,7"
      BITFLD.LONG 0x00 24.--26. "  RFCTRL_CHANNEL_SSET6  , Software set the uni_rfctl[6] channels active or not, active high. [24] for lte subsystem; [25] for wtg subsystem; [26] for gge subsystem." "0,1,2,3,4,5,6,7"
      BITFLD.LONG 0x00 21.--23. "  RFCTRL_CHANNEL_SSET5 , Software set the uni_rfctl[5] channels active or not, active high. [21] for lte subsystem; [22] for wtg subsystem; [23] for gge subsystem." "0,1,2,3,4,5,6,7"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 18.--20. "  RFCTRL_CHANNEL_SSET4 , Software set the uni_rfctl[4] channels active or not, active high. [18] for lte subsystem; [19] for wtg subsystem; [20] for gge subsystem." "0,1,2,3,4,5,6,7"
      BITFLD.LONG 0x00 15.--17. "         RFCTRL_CHANNEL_SSET3  , Software set the uni_rfctl[3] channels active or not, active high. [15] for lte subsystem; [16] for wtg subsystem; [17] for gge subsystem." "0,1,2,3,4,5,6,7"
      BITFLD.LONG 0x00 12.--14. "  RFCTRL_CHANNEL_SSET2  , Software set the uni_rfctl[2] channels active or not, active high. [12] for lte subsystem; [13] for wtg subsystem; [14] for gge subsystem." "0,1,2,3,4,5,6,7"
      BITFLD.LONG 0x00 9.--11. "  RFCTRL_CHANNEL_SSET1 , Software set the uni_rfctl[1] channels active or not, active high. [9] for lte subsystem; [10] for wtg subsystem; [11] for gge subsystem." "0,1,2,3,4,5,6,7"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 6.--8. "  RFCTRL_CHANNEL_SSET0 , Software set the uni_rfctl[0] channels active or not, active high. [6] for lte subsystem; [7] for wtg subsystem; [8] for gge subsystem." "0,1,2,3,4,5,6,7"
      BITFLD.LONG 0x00 3.--5. "         RFCTRL_CHANNEL_MASK15 , Enable the uni_rfctl[15] channels when the rfctrl15_xx is active. Active high.[3] for lte subsystem; [4] for wtg subsystem; [5] for gge subsystem." "0,1,2,3,4,5,6,7"
      BITFLD.LONG 0x00 0.--2. "  RFCTRL_CHANNEL_MASK14 , Enable the uni_rfctl[14] channels when the rfctrl15_xx is active. Active high.[0] for lte subsystem; [1] for wtg subsystem; [2] for gge subsystem." "0,1,2,3,4,5,6,7"
  GROUP.LONG 0x0190++0x3 "0x02070000 + 0x0190"
    LINE.LONG 0x00 "MDAR_CFG7"
      BITFLD.LONG 0x00 21.--23. "  RFCTRL_CHANNEL_SSET15 , Software set the uni_rfctl[15] channels active or not, active high. [21] for lte subsystem; [22] for wtg subsystem; [23] for gge subsystem." "0,1,2,3,4,5,6,7"
      BITFLD.LONG 0x00 18.--20. "  RFCTRL_CHANNEL_SSET14 , Software set the uni_rfctl[14] channels active or not, active high. [18] for lte subsystem; [19] for wtg subsystem; [20] for gge subsystem." "0,1,2,3,4,5,6,7"
      BITFLD.LONG 0x00 15.--17. "  RFCTRL_CHANNEL_SSET13 , Software set the uni_rfctl[13] channels active or not, active high. [15] for lte subsystem; [16] for wtg subsystem; [17] for gge subsystem." "0,1,2,3,4,5,6,7"
      BITFLD.LONG 0x00 12.--14. "  RFCTRL_CHANNEL_SSET12 , Software set the uni_rfctl[12] channels active or not, active high. [12] for lte subsystem; [13] for wtg subsystem; [14] for gge subsystem." "0,1,2,3,4,5,6,7"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 9.--11. "  RFCTRL_CHANNEL_SSET11 , Software set the uni_rfctl[11] channels active or not, active high. [9] for lte subsystem; [10] for wtg subsystem; [11] for gge subsystem." "0,1,2,3,4,5,6,7"
      BITFLD.LONG 0x00 6.--8. "  RFCTRL_CHANNEL_SSET10 , Software set the uni_rfctl[10] channels active or not, active high. [6] for lte subsystem; [7] for wtg subsystem; [8] for gge subsystem." "0,1,2,3,4,5,6,7"
      BITFLD.LONG 0x00 3.--5. "  RFCTRL_CHANNEL_SSET9  , Software set the uni_rfctl[9] channels active or not, active high. [3] for lte subsystem; [4] for wtg subsystem; [5] for gge subsystem." "0,1,2,3,4,5,6,7"
      BITFLD.LONG 0x00 0.--2. "  RFCTRL_CHANNEL_SSET8  , Software set the uni_rfctl[8] channels active or not, active high. [0] for lte subsystem; [1] for wtg subsystem; [2] for gge subsystem." "0,1,2,3,4,5,6,7"
      TEXTLINE "                           "
  GROUP.LONG 0x0194++0x3 "0x02070000 + 0x0194"
    LINE.LONG 0x00 "MDAR_CFG8"
      BITFLD.LONG 0x00 30.--31. "  Reserved              , Reserved" "Reserved,Reserved,Reserved,Reserved"
      BITFLD.LONG 0x00 27.--29. "  RFCTRL_CHANNEL_MASK19 , Enable the uni_rfctl[19] channels when the rfctrl15_xx is active. Active high.[27] for lte subsystem; [28] for wtg subsystem; [29] for gge subsystem." "0,1,2,3,4,5,6,7"
      BITFLD.LONG 0x00 24.--26. "         RFCTRL_CHANNEL_MASK18 , Enable the uni_rfctl[18] channels when the rfctrl15_xx is active. Active high.[24] for lte subsystem; [25] for wtg subsystem; [26] for gge subsystem." "0,1,2,3,4,5,6,7"
      BITFLD.LONG 0x00 21.--23. "         RFCTRL_CHANNEL_MASK17 , Enable the uni_rfctl[17] channels when the rfctrl15_xx is active. Active high.[21] for lte subsystem; [22] for wtg subsystem; [23] for gge subsystem." "0,1,2,3,4,5,6,7"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 18.--20. "  RFCTRL_CHANNEL_MASK16 , Enable the uni_rfctl[16] channels when the rfctrl15_xx is active. Active high.[18] for lte subsystem; [19] for wtg subsystem; [20] for gge subsystem." "0,1,2,3,4,5,6,7"
      BITFLD.LONG 0x00 17. "         Reserved              , Reserved." "Reserved,Reserved"
      BITFLD.LONG 0x00 16. "  Reserved              , Reserved." "Reserved,Reserved"
      BITFLD.LONG 0x00 14.--15. "  RFCTRL3130_SST        , For future use" "0,1,2,3"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 0.--13. "  RFCTRL2916_SST        , The default value of the uni_rfctl[29:16] when no communication system get the control right of these pasd." "none"
  GROUP.LONG 0x0198++0x3 "0x02070000 + 0x0198"
    LINE.LONG 0x00 "MDAR_CFG9"
      BITFLD.LONG 0x00 30.--31. "  Reserved              , Reserved." "Reserved,Reserved,Reserved,Reserved"
      BITFLD.LONG 0x00 27.--29. "  RFCTRL_CHANNEL_MASK29 , Enable the uni_rfctl[29] channels when the rfctrl15_xx is active. Active high.[27] for lte subsystem; [28] for wtg subsystem; [29] for gge subsystem." "0,1,2,3,4,5,6,7"
      BITFLD.LONG 0x00 24.--26. "  RFCTRL_CHANNEL_MASK28 , Enable the uni_rfctl[28] channels when the rfctrl15_xx is active. Active high.[24] for lte subsystem; [25] for wtg subsystem; [26] for gge subsystem." "0,1,2,3,4,5,6,7"
      BITFLD.LONG 0x00 21.--23. "  RFCTRL_CHANNEL_MASK27 , Enable the uni_rfctl[27] channels when the rfctrl15_xx is active. Active high.[21] for lte subsystem; [22] for wtg subsystem; [23] for gge subsystem." "0,1,2,3,4,5,6,7"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 18.--20. "  RFCTRL_CHANNEL_MASK26 , Enable the uni_rfctl[26] channels when the rfctrl15_xx is active. Active high.[18] for lte subsystem; [19] for wtg subsystem; [20] for gge subsystem." "0,1,2,3,4,5,6,7"
      BITFLD.LONG 0x00 15.--17. "         RFCTRL_CHANNEL_MASK25 , Enable the uni_rfctl[25] channels when the rfctrl15_xx is active. Active high.[15] for lte subsystem; [16] for wtg subsystem; [17] for gge subsystem." "0,1,2,3,4,5,6,7"
      BITFLD.LONG 0x00 12.--14. "  RFCTRL_CHANNEL_MASK24 , Enable the uni_rfctl[24] channels when the rfctrl15_xx is active. Active high.[12] for lte subsystem; [13] for wtg subsystem; [14] for gge subsystem." "0,1,2,3,4,5,6,7"
      BITFLD.LONG 0x00 9.--11. "  RFCTRL_CHANNEL_MASK23 , Enable the uni_rfctl[23] channels when the rfctrl15_xx is active. Active high.[9] for lte subsystem; [10] for wtg subsystem; [11] for gge subsystem." "0,1,2,3,4,5,6,7"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 6.--8. "  RFCTRL_CHANNEL_MASK22 , Enable the uni_rfctl[22] channels when the rfctrl15_xx is active. Active high.[6] for lte subsystem; [7] for wtg subsystem; [8] for gge subsystem." "0,1,2,3,4,5,6,7"
      BITFLD.LONG 0x00 3.--5. "         RFCTRL_CHANNEL_MASK21 , Enable the uni_rfctl[21] channels when the rfctrl15_xx is active. Active high.[3] for lte subsystem; [4] for wtg subsystem; [5] for gge subsystem." "0,1,2,3,4,5,6,7"
      BITFLD.LONG 0x00 0.--2. "  RFCTRL_CHANNEL_MASK20 , Enable the uni_rfctl[20] channels when the rfctrl15_xx is active. Active high.[0] for lte subsystem; [1] for wtg subsystem; [2] for gge subsystem." "0,1,2,3,4,5,6,7"
  GROUP.LONG 0x019C++0x3 "0x02070000 + 0x019C"
    LINE.LONG 0x00 "MDAR_CFG10"
      BITFLD.LONG 0x00 30.--31. "  Reserved              , Reserved." "Reserved,Reserved,Reserved,Reserved"
      BITFLD.LONG 0x00 27.--29. "  RFCTRL_CHANNEL_SSET23 , Software set the uni_rfctl[23] channels active or not, active high. [27] for lte subsystem; [28] for wtg subsystem; [29] for gge subsystem." "0,1,2,3,4,5,6,7"
      BITFLD.LONG 0x00 24.--26. "  RFCTRL_CHANNEL_SSET22 , Software set the uni_rfctl[22] channels active or not, active high. [24] for lte subsystem; [25] for wtg subsystem; [26] for gge subsystem." "0,1,2,3,4,5,6,7"
      BITFLD.LONG 0x00 21.--23. "  RFCTRL_CHANNEL_SSET21 , Software set the uni_rfctl[21] channels active or not, active high. [21] for lte subsystem; [22] for wtg subsystem; [23] for gge subsystem." "0,1,2,3,4,5,6,7"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 18.--20. "  RFCTRL_CHANNEL_SSET20 , Software set the uni_rfctl[20] channels active or not, active high. [18] for lte subsystem; [19] for wtg subsystem; [20] for gge subsystem." "0,1,2,3,4,5,6,7"
      BITFLD.LONG 0x00 15.--17. "         RFCTRL_CHANNEL_SSET19 , Software set the uni_rfctl[19] channels active or not, active high. [15] for lte subsystem; [16] for wtg subsystem; [17] for gge subsystem." "0,1,2,3,4,5,6,7"
      BITFLD.LONG 0x00 12.--14. "  RFCTRL_CHANNEL_SSET18 , Software set the uni_rfctl[18] channels active or not, active high. [12] for lte subsystem; [13] for wtg subsystem; [14] for gge subsystem." "0,1,2,3,4,5,6,7"
      BITFLD.LONG 0x00 9.--11. "  RFCTRL_CHANNEL_SSET17 , Software set the uni_rfctl[17] channels active or not, active high. [9] for lte subsystem; [10] for wtg subsystem; [11] for gge subsystem." "0,1,2,3,4,5,6,7"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 6.--8. "  RFCTRL_CHANNEL_SSET16 , Software set the uni_rfctl[16] channels active or not, active high. [6] for lte subsystem; [7] for wtg subsystem; [8] for gge subsystem." "0,1,2,3,4,5,6,7"
      BITFLD.LONG 0x00 3.--5. "         RFCTRL_CHANNEL_MASK31 , Enable the uni_rfctl[31] channels when the rfctrl15_xx is active. Active high.[3] for lte subsystem; [4] for wtg subsystem; [5] for gge subsystem." "0,1,2,3,4,5,6,7"
      BITFLD.LONG 0x00 0.--2. "  RFCTRL_CHANNEL_MASK30 , Enable the uni_rfctl[30] channels when the rfctrl15_xx is active. Active high.[0] for lte subsystem; [1] for wtg subsystem; [2] for gge subsystem." "0,1,2,3,4,5,6,7"
  GROUP.LONG 0x01B0++0x3 "0x02070000 + 0x01B0"
    LINE.LONG 0x00 "MDAR_CFG11"
      BITFLD.LONG 0x00 21.--23. "  RFCTRL_CHANNEL_SSET31 , Software set the uni_rfctl[31] channels active or not, active high. [21] for lte subsystem; [22] for wtg subsystem; [23] for gge subsystem." "0,1,2,3,4,5,6,7"
      BITFLD.LONG 0x00 18.--20. "  RFCTRL_CHANNEL_SSET30 , Software set the uni_rfctl[30] channels active or not, active high. [18] for lte subsystem; [19] for wtg subsystem; [20] for gge subsystem." "0,1,2,3,4,5,6,7"
      BITFLD.LONG 0x00 15.--17. "  RFCTRL_CHANNEL_SSET29 , Software set the uni_rfctl[29] channels active or not, active high. [15] for lte subsystem; [16] for wtg subsystem; [17] for gge subsystem." "0,1,2,3,4,5,6,7"
      BITFLD.LONG 0x00 12.--14. "  RFCTRL_CHANNEL_SSET28 , Software set the uni_rfctl[28] channels active or not, active high. [12] for lte subsystem; [13] for wtg subsystem; [14] for gge subsystem." "0,1,2,3,4,5,6,7"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 9.--11. "  RFCTRL_CHANNEL_SSET27 , Software set the uni_rfctl[27] channels active or not, active high. [9] for lte subsystem; [10] for wtg subsystem; [11] for gge subsystem." "0,1,2,3,4,5,6,7"
      BITFLD.LONG 0x00 6.--8. "  RFCTRL_CHANNEL_SSET26 , Software set the uni_rfctl[26] channels active or not, active high. [6] for lte subsystem; [7] for wtg subsystem; [8] for gge subsystem." "0,1,2,3,4,5,6,7"
      BITFLD.LONG 0x00 3.--5. "  RFCTRL_CHANNEL_SSET25 , Software set the uni_rfctl[25] channels active or not, active high. [3] for lte subsystem; [4] for wtg subsystem; [5] for gge subsystem." "0,1,2,3,4,5,6,7"
      BITFLD.LONG 0x00 0.--2. "  RFCTRL_CHANNEL_SSET24 , Software set the uni_rfctl[24] channels active or not, active high. [0] for lte subsystem; [1] for wtg subsystem; [2] for gge subsystem." "0,1,2,3,4,5,6,7"
      TEXTLINE "                           "
  GROUP.LONG 0x01B4++0x3 "0x02070000 + 0x01B4"
    LINE.LONG 0x00 "MDAR_CFG12"
      BITFLD.LONG 0x00 31. "  Reserved , Reserved." "Reserved,Reserved"
      BITFLD.LONG 0x00 16.--30. "  RFCTRL_WTGCFGH , When control right of uni_rfctrl[x+15] has been getten by the wtg system,  if rfctrl_wtgcfgh[x] is set high, rfctrl_wtg[x] will be mapped to uni_rfctrl[x+15], otherwise 0 will be set to uni_rfctrl[x+15]." "none"
      BITFLD.LONG 0x00 15. "  Reserved , Reserved." "Reserved,Reserved"
      BITFLD.LONG 0x00 0.--14. "  RFCTRL_WTGCFGL , When control right of uni_rfctrl[x] has been getten by the wtg system,  if rfctrl_wtgcfgl[x] is set high, rfctrl_wtg[x] will be mapped to uni_rfctrl[x], otherwise 0 will be set to uni_rfctrl[x]." "none"
      TEXTLINE "                           "
  GROUP.LONG 0x01B8++0x3 "0x02070000 + 0x01B8"
    LINE.LONG 0x00 "MDAR_CFG13"
      BITFLD.LONG 0x00 31. "  Reserved , Reserved." "Reserved,Reserved"
      BITFLD.LONG 0x00 16.--30. "  RFCTRL_GGECFGH , When control right of uni_rfctrl[x+15] has been getten by the gge system,  if rfctrl_ggecfgh[x] is set high, rfctrl_gge[x] will be mapped to uni_rfctrl[x+15], otherwise 0 will be set to uni_rfctrl[x+15]." "none"
      BITFLD.LONG 0x00 15. "  Reserved , Reserved." "Reserved,Reserved"
      BITFLD.LONG 0x00 0.--14. "  RFCTRL_GGECFGL , When control right of uni_rfctrl[x] has been getten by the gge system,  if rfctrl_ggecfgl[x] is set high, rfctrl_wtg[x] will be mapped to uni_rfctrl[x], otherwise 0 will be set to uni_rfctrl[x]." "none"
      TEXTLINE "                           "
  GROUP.LONG 0x01BC++0x3 "0x02070000 + 0x01BC"
    LINE.LONG 0x00 "MDAR_CFG14"
  GROUP.LONG 0x1C0++0x3 "0x02070000 + 0x1C0"
    LINE.LONG 0x00 "MDAR_CFG15"
      BITFLD.LONG 0x00 0.--23. "  MDAR_ANALOG_BB_RSV , Reserved bits, default 0. MDAR_ANALOG_BB_RSV[11:8] control second ADC/DAC 0000 (default, normal work) 0001       I SEC_ADC<---  I  SEC_DAC 0010      Q SEC_ADC<---  Q  SEC_DAC 0100      Q SEC_ADC<---  I  SEC_DAC 1000       I SEC_ADC <---  Q  SEC_DAC 0011       I SEC_ADC <---  I  SEC_DAC                 Q SEC_ADC<---  Q  SEC_DAC               (SEC ADC _SDAC loop enable ) others   not used   MDAR_ANALOG_BB_RSV[7:0] control main ADC/DAC 00000000 (default, normal work) 00000001   I MAIN_ADC  <---  I  MAIN_DAC 00000010   Q MAIN_ADC  <---  Q  MAIN_DAC 00000100   Q MAIN_ADC  <---  I  MAIN_DAC 00001000    I MAIN_ADC   <---  Q  MAIN_DAC 00010000    I MDIV_ADC  <---  I  MAIN_DAC 00100000    Q MDIV_ADC  <---  Q  MAIN_DAC 01000000    Q MDIV_ADC  <---  I  MAIN_DAC 10000000     I MDIV_ADC  <---  Q  MAIN_DAC 00000011     I MAIN_ADC  <---  I  MAIN_DAC                         Q MAIN_ADC  <---  Q  MAIN_DAC                       (MAIN  ADC _MDAC loop enable ) 00110000     I MDIV_ADC  <---  I  MAIN_DAC                          I MDIV_ADC  <---  I  MAIN_DAC                        (MDIV ADC _MDAC loop enable ) others            not used" "none"
  GROUP.LONG 0x1C4++0x3 "0x02070000 + 0x1C4"
    LINE.LONG 0x00 "MDAR_IMB_CFG10"
      BITFLD.LONG 0x00 21. "  ADC1_IMBP_CLK_SEL_5 , define the ADC1 process function in the free mode. 1:the processing clock is the invert clock of ADC1. 0:the processing clock is the samet clock of ADC1." "the processing clock is the samet clock of ADC,the processing clock is the invert clock of ADC"
      BITFLD.LONG 0x00 20. "  ADC1_IMBP_CLK_SEL_4 , define the ADC1 process function in the GGE mode. 1:the processing clock is the invert clock of ADC1. 0:the processing clock is the samet clock of ADC1." "the processing clock is the samet clock of ADC,the processing clock is the invert clock of ADC"
      BITFLD.LONG 0x00 19. "  ADC1_IMBP_CLK_SEL_3 , define the ADC1 process function in the WCDMA mode. 1:the processing clock is the invert clock of ADC1. 0:the processing clock is the samet clock of ADC1." "the processing clock is the samet clock of ADC,the processing clock is the invert clock of ADC"
      BITFLD.LONG 0x00 18. "  ADC1_IMBP_CLK_SEL_2 , define the ADC1 process function in the GSM mode of the WTG sub-system. 1:the processing clock is the invert clock of ADC1. 0:the processing clock is the samet clock of ADC1." "the processing clock is the samet clock of ADC,the processing clock is the invert clock of ADC"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 17. "  ADC1_IMBP_CLK_SEL_1 , define the ADC1 process function in TDSCDMA mode. 1:the processing clock is the invert clock of ADC1. 0:the processing clock is the samet clock of ADC1." "the processing clock is the samet clock of ADC,the processing clock is the invert clock of ADC"
      BITFLD.LONG 0x00 16. "  ADC1_IMBP_CLK_SEL_0 , define clock of the ADC1 process function in the LTE mode. 1:the processing clock is the invert clock of ADC1. 0:the processing clock is the samet clock of ADC1." "the processing clock is the samet clock of ADC,the processing clock is the invert clock of ADC"
      BITFLD.LONG 0x00 14.--15. "  Reserved            , Reserved." "Reserved,Reserved,Reserved,Reserved"
      BITFLD.LONG 0x00 13. "                                         DAC1_IMBP_BYPASS_5  , define the DAC1 process function in the free mode. 0:the imblance is active 1:the imblance is inactive" "the imblance is active,the imblance is inactive"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 12. "  DAC1_IMBP_BYPASS_4  , define the DAC1 process function in the GGE mode. 0:the imblance is active 1:the imblance is inactive" "the imblance is active,the imblance is inactive"
      BITFLD.LONG 0x00 11. "                         DAC1_IMBP_BYPASS_3  , define the DAC1 process function in the WCDMA mode. 0:the imblance is active 1:the imblance is inactive" "the imblance is active,the imblance is inactive"
      BITFLD.LONG 0x00 10. "                         DAC1_IMBP_BYPASS_2  , define the DAC1 process function in the GSM mode of the WTG sub-system. 0:the imblance is active 1:the imblance is inactive" "the imblance is active,the imblance is inactive"
      BITFLD.LONG 0x00 9. "                         DAC1_IMBP_BYPASS_1  , define the DAC1 process function in TDSCDMA mode. 0:the imblance is active 1:the imblance is inactive" "the imblance is active,the imblance is inactive"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 8. "  DAC1_IMBP_BYPASS_0  , define the DAC1 process function in the LTE mode. 0:the imblance is active 1:the imblance is inactive" "the imblance is active,the imblance is inactive"
      BITFLD.LONG 0x00 6.--7. "                         Reserved            , Reserved." "Reserved,Reserved,Reserved,Reserved"
      BITFLD.LONG 0x00 5. "                                         ADC1_IMBP_BYPASS_5  , define the ADC1 process function in the free mode. 0:the imblance is active 1:the imblance is inactive" "the imblance is active,the imblance is inactive"
      BITFLD.LONG 0x00 4. "                         ADC1_IMBP_BYPASS_4  , define the ADC1 process function in the GGE mode. 0:the imblance is active 1:the imblance is inactive" "the imblance is active,the imblance is inactive"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 3. "  ADC1_IMBP_BYPASS_3  , define the ADC1 process function in the WCDMA mode. 0:the imblance is active 1:the imblance is inactive" "the imblance is active,the imblance is inactive"
      BITFLD.LONG 0x00 2. "                         ADC1_IMBP_BYPASS_2  , define the ADC1 process function in the GSM mode of the WTG sub-system. 0:the imblance is active 1:the imblance is inactive" "the imblance is active,the imblance is inactive"
      BITFLD.LONG 0x00 1. "                         ADC1_IMBP_BYPASS_1  , define the ADC1 process function in TDSCDMA mode. 0:the imblance is active 1:the imblance is inactive" "the imblance is active,the imblance is inactive"
      BITFLD.LONG 0x00 0. "                         ADC1_IMBP_BYPASS_0  , define the ADC1 process function in the LTE mode. 0:the imblance is active 1:the imblance is inactive" "the imblance is active,the imblance is inactive"
      TEXTLINE "                           "
  GROUP.LONG 0x1C8++0x3 "0x02070000 + 0x1C8"
    LINE.LONG 0x00 "MDAR_IMB_CFG11"
      BITFLD.LONG 0x00 30.--31. "  Reserved , Reserved." "Reserved,Reserved,Reserved,Reserved"
      BITFLD.LONG 0x00 16.--29. "  ADC1_BAL_B , the imblance process parameter B for ADC1" "none"
      BITFLD.LONG 0x00 14.--15. "  Reserved , Reserved." "Reserved,Reserved,Reserved,Reserved"
      BITFLD.LONG 0x00 0.--13. "  ADC1_BAL_A , the imblance process parameter A for ADC1" "none"
      TEXTLINE "                           "
  GROUP.LONG 0x1CC++0x3 "0x02070000 + 0x1CC"
    LINE.LONG 0x00 "MDAR_IMB_CFG12"
      BITFLD.LONG 0x00 30.--31. "  Reserved , Reserved." "Reserved,Reserved,Reserved,Reserved"
      BITFLD.LONG 0x00 16.--29. "  ADC1_BAL_D , the imblance process parameter D for ADC1" "none"
      BITFLD.LONG 0x00 14.--15. "  Reserved , Reserved." "Reserved,Reserved,Reserved,Reserved"
      BITFLD.LONG 0x00 0.--13. "  ADC1_BAL_C , the imblance process parameter C for ADC1" "none"
      TEXTLINE "                           "
  GROUP.LONG 0x1D0++0x3 "0x02070000 + 0x1D0"
    LINE.LONG 0x00 "MDAR_IMB_CFG13"
      BITFLD.LONG 0x00 30.--31. "  Reserved , Reserved." "Reserved,Reserved,Reserved,Reserved"
      BITFLD.LONG 0x00 16.--29. "  DAC1_BAL_B , the imblance process parameter B for DAC1" "none"
      BITFLD.LONG 0x00 14.--15. "  Reserved , Reserved." "Reserved,Reserved,Reserved,Reserved"
      BITFLD.LONG 0x00 0.--13. "  DAC1_BAL_A , the imblance process parameter A for DAC1" "none"
      TEXTLINE "                           "
  GROUP.LONG 0x1D4++0x3 "0x02070000 + 0x1D4"
    LINE.LONG 0x00 "MDAR_IMB_CFG14"
      BITFLD.LONG 0x00 30.--31. "  Reserved , Reserved." "Reserved,Reserved,Reserved,Reserved"
      BITFLD.LONG 0x00 16.--29. "  DAC1_BAL_D , the imblance process parameter D for DAC1" "none"
      BITFLD.LONG 0x00 14.--15. "  Reserved , Reserved." "Reserved,Reserved,Reserved,Reserved"
      BITFLD.LONG 0x00 0.--13. "  DAC1_BAL_C , the imblance process parameter C for DAC1" "none"
      TEXTLINE "                           "
  GROUP.LONG 0x1D8++0x3 "0x02070000 + 0x1D8"
    LINE.LONG 0x00 "MDAR_IMB_CFG20"
      BITFLD.LONG 0x00 21. "  ADC2_IMBP_CLK_SEL_5 , define the ADC2 process function in the free mode. 1:the processing clock is the invert clock of ADC2. 0:the processing clock is the samet clock of ADC2." "the processing clock is the samet clock of ADC,the processing clock is the invert clock of ADC"
      BITFLD.LONG 0x00 20. "  ADC2_IMBP_CLK_SEL_4 , define the ADC2 process function in the GGE mode. 1:the processing clock is the invert clock of ADC2. 0:the processing clock is the samet clock of ADC2." "the processing clock is the samet clock of ADC,the processing clock is the invert clock of ADC"
      BITFLD.LONG 0x00 19. "  ADC2_IMBP_CLK_SEL_3 , define the ADC2 process function in the WCDMA mode. 1:the processing clock is the invert clock of ADC2. 0:the processing clock is the samet clock of ADC2." "the processing clock is the samet clock of ADC,the processing clock is the invert clock of ADC"
      BITFLD.LONG 0x00 18. "  ADC2_IMBP_CLK_SEL_2 , define the ADC2 process function in the GSM mode of the WTG sub-system. 1:the processing clock is the invert clock of ADC2. 0:the processing clock is the samet clock of ADC2." "the processing clock is the samet clock of ADC,the processing clock is the invert clock of ADC"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 17. "  ADC2_IMBP_CLK_SEL_1 , define the ADC2 process function in TDSCDMA mode. 1:the processing clock is the invert clock of ADC2. 0:the processing clock is the samet clock of ADC2." "the processing clock is the samet clock of ADC,the processing clock is the invert clock of ADC"
      BITFLD.LONG 0x00 16. "  ADC2_IMBP_CLK_SEL_0 , define clock of the ADC2 process function in the LTE mode. 1:the processing clock is the invert clock of ADC2. 0:the processing clock is the samet clock of ADC2." "the processing clock is the samet clock of ADC,the processing clock is the invert clock of ADC"
      BITFLD.LONG 0x00 14.--15. "  Reserved            , Reserved." "Reserved,Reserved,Reserved,Reserved"
      BITFLD.LONG 0x00 13. "                                         DAC2_IMBP_BYPASS_5  , define the DAC2 process function in the free mode. 0:the imblance is active 1:the imblance is inactive" "the imblance is active,the imblance is inactive"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 12. "  DAC2_IMBP_BYPASS_4  , define the DAC2 process function in the GGE mode. 0:the imblance is active 1:the imblance is inactive" "the imblance is active,the imblance is inactive"
      BITFLD.LONG 0x00 11. "                         DAC2_IMBP_BYPASS_3  , define the DAC2 process function in the WCDMA mode. 0:the imblance is active 1:the imblance is inactive" "the imblance is active,the imblance is inactive"
      BITFLD.LONG 0x00 10. "                         DAC2_IMBP_BYPASS_2  , define the DAC2 process function in the GSM mode of the WTG sub-system. 0:the imblance is active 1:the imblance is inactive" "the imblance is active,the imblance is inactive"
      BITFLD.LONG 0x00 9. "                         DAC2_IMBP_BYPASS_1  , define the DAC2 process function in TDSCDMA mode. 0:the imblance is active 1:the imblance is inactive" "the imblance is active,the imblance is inactive"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 8. "  DAC2_IMBP_BYPASS_0  , define the DAC2 process function in the LTE mode. 0:the imblance is active 1:the imblance is inactive" "the imblance is active,the imblance is inactive"
      BITFLD.LONG 0x00 6.--7. "                         Reserved            , Reserved." "Reserved,Reserved,Reserved,Reserved"
      BITFLD.LONG 0x00 5. "                                         ADC2_IMBP_BYPASS_5  , define the ADC2 process function in the free mode. 0:the imblance is active 1:the imblance is inactive" "the imblance is active,the imblance is inactive"
      BITFLD.LONG 0x00 4. "                         ADC2_IMBP_BYPASS_4  , define the ADC2 process function in the GGE mode. 0:the imblance is active 1:the imblance is inactive" "the imblance is active,the imblance is inactive"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 3. "  ADC2_IMBP_BYPASS_3  , define the ADC2 process function in the WCDMA mode. 0:the imblance is active 1:the imblance is inactive" "the imblance is active,the imblance is inactive"
      BITFLD.LONG 0x00 2. "                         ADC2_IMBP_BYPASS_2  , define the ADC2 process function in the GSM mode of the WTG sub-system. 0:the imblance is active 1:the imblance is inactive" "the imblance is active,the imblance is inactive"
      BITFLD.LONG 0x00 1. "                         ADC2_IMBP_BYPASS_1  , define the ADC2 process function in TDSCDMA mode. 0:the imblance is active 1:the imblance is inactive" "the imblance is active,the imblance is inactive"
      BITFLD.LONG 0x00 0. "                         ADC2_IMBP_BYPASS_0  , define the ADC2 process function in the LTE mode. 0:the imblance is active 1:the imblance is inactive" "the imblance is active,the imblance is inactive"
      TEXTLINE "                           "
  GROUP.LONG 0x1DC++0x3 "0x02070000 + 0x1DC"
    LINE.LONG 0x00 "MDAR_IMB_CFG21"
      BITFLD.LONG 0x00 30.--31. "  Reserved , Reserved." "Reserved,Reserved,Reserved,Reserved"
      BITFLD.LONG 0x00 16.--29. "  ADC2_BAL_B , the imblance process parameter B for ADC2" "none"
      BITFLD.LONG 0x00 14.--15. "  Reserved , Reserved." "Reserved,Reserved,Reserved,Reserved"
      BITFLD.LONG 0x00 0.--13. "  ADC2_BAL_A , the imblance process parameter A for ADC2" "none"
      TEXTLINE "                           "
  GROUP.LONG 0x1E0++0x3 "0x02070000 + 0x1E0"
    LINE.LONG 0x00 "MDAR_IMB_CFG22"
      BITFLD.LONG 0x00 30.--31. "  Reserved , Reserved." "Reserved,Reserved,Reserved,Reserved"
      BITFLD.LONG 0x00 16.--29. "  ADC2_BAL_D , the imblance process parameter D for ADC2" "none"
      BITFLD.LONG 0x00 14.--15. "  Reserved , Reserved." "Reserved,Reserved,Reserved,Reserved"
      BITFLD.LONG 0x00 0.--13. "  ADC2_BAL_C , the imblance process parameter C for ADC2" "none"
      TEXTLINE "                           "
  GROUP.LONG 0x1E4++0x3 "0x02070000 + 0x1E4"
    LINE.LONG 0x00 "MDAR_IMB_CFG23"
      BITFLD.LONG 0x00 30.--31. "  Reserved , Reserved." "Reserved,Reserved,Reserved,Reserved"
      BITFLD.LONG 0x00 16.--29. "  DAC2_BAL_B , the imblance process parameter B for DAC2" "none"
      BITFLD.LONG 0x00 14.--15. "  Reserved , Reserved." "Reserved,Reserved,Reserved,Reserved"
      BITFLD.LONG 0x00 0.--13. "  DAC2_BAL_A , the imblance process parameter A for DAC2" "none"
      TEXTLINE "                           "
  GROUP.LONG 0x1E8++0x3 "0x02070000 + 0x1E8"
    LINE.LONG 0x00 "MDAR_IMB_CFG24"
      BITFLD.LONG 0x00 30.--31. "  Reserved , Reserved." "Reserved,Reserved,Reserved,Reserved"
      BITFLD.LONG 0x00 16.--29. "  DAC2_BAL_D , the imblance process parameter D for DAC2" "none"
      BITFLD.LONG 0x00 14.--15. "  Reserved , Reserved." "Reserved,Reserved,Reserved,Reserved"
      BITFLD.LONG 0x00 0.--13. "  DAC2_BAL_C , the imblance process parameter C for DAC2" "none"
      TEXTLINE "                           "
  GROUP.LONG 0x1EC++0x3 "0x02070000 + 0x1EC"
    LINE.LONG 0x00 "MDAR_IMB_CFG30"
      BITFLD.LONG 0x00 21. "  ADC3_IMBP_CLK_SEL_5 , define the ADC3 process function in the free mode. 1:the processing clock is the invert clock of ADC3. 0:the processing clock is the samet clock of ADC3." "the processing clock is the samet clock of ADC,the processing clock is the invert clock of ADC"
      BITFLD.LONG 0x00 20. "  ADC3_IMBP_CLK_SEL_4 , define the ADC3 process function in the GGE mode. 1:the processing clock is the invert clock of ADC3. 0:the processing clock is the samet clock of ADC3." "the processing clock is the samet clock of ADC,the processing clock is the invert clock of ADC"
      BITFLD.LONG 0x00 19. "  ADC3_IMBP_CLK_SEL_3 , define the ADC3 process function in the WCDMA mode. 1:the processing clock is the invert clock of ADC3. 0:the processing clock is the samet clock of ADC3." "the processing clock is the samet clock of ADC,the processing clock is the invert clock of ADC"
      BITFLD.LONG 0x00 18. "  ADC3_IMBP_CLK_SEL_2 , define the ADC3 process function in the GSM mode of the WTG sub-system. 1:the processing clock is the invert clock of ADC3. 0:the processing clock is the samet clock of ADC3." "the processing clock is the samet clock of ADC,the processing clock is the invert clock of ADC"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 17. "  ADC3_IMBP_CLK_SEL_1 , define the ADC3 process function in TDSCDMA mode. 1:the processing clock is the invert clock of ADC3. 0:the processing clock is the samet clock of ADC3." "the processing clock is the samet clock of ADC,the processing clock is the invert clock of ADC"
      BITFLD.LONG 0x00 16. "  ADC3_IMBP_CLK_SEL_0 , define clock of the ADC3 process function in the LTE mode. 1:the processing clock is the invert clock of ADC3. 0:the processing clock is the samet clock of ADC3." "the processing clock is the samet clock of ADC,the processing clock is the invert clock of ADC"
      BITFLD.LONG 0x00 14.--15. "  Reserved            , Reserved." "Reserved,Reserved,Reserved,Reserved"
      BITFLD.LONG 0x00 13. "                                         DAC3_IMBP_BYPASS_5  , define the DAC3 process function in the free mode. 0:the imblance is active 1:the imblance is inactive" "the imblance is active,the imblance is inactive"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 12. "  DAC3_IMBP_BYPASS_4  , define the DAC3 process function in the GGE mode. 0:the imblance is active 1:the imblance is inactive" "the imblance is active,the imblance is inactive"
      BITFLD.LONG 0x00 11. "                         DAC3_IMBP_BYPASS_3  , define the DAC3 process function in the WCDMA mode. 0:the imblance is active 1:the imblance is inactive" "the imblance is active,the imblance is inactive"
      BITFLD.LONG 0x00 10. "                         DAC3_IMBP_BYPASS_2  , define the DAC3 process function in the GSM mode of the WTG sub-system. 0:the imblance is active 1:the imblance is inactive" "the imblance is active,the imblance is inactive"
      BITFLD.LONG 0x00 9. "                         DAC3_IMBP_BYPASS_1  , define the DAC3 process function in TDSCDMA mode. 0:the imblance is active 1:the imblance is inactive" "the imblance is active,the imblance is inactive"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 8. "  DAC3_IMBP_BYPASS_0  , define the DAC3 process function in the LTE mode. 0:the imblance is active 1:the imblance is inactive" "the imblance is active,the imblance is inactive"
      BITFLD.LONG 0x00 6.--7. "                         Reserved            , Reserved." "Reserved,Reserved,Reserved,Reserved"
      BITFLD.LONG 0x00 5. "                                         ADC3_IMBP_BYPASS_5  , define the ADC3 process function in the free mode. 0:the imblance is active 1:the imblance is inactive" "the imblance is active,the imblance is inactive"
      BITFLD.LONG 0x00 4. "                         ADC3_IMBP_BYPASS_4  , define the ADC3 process function in the GGE mode. 0:the imblance is active 1:the imblance is inactive" "the imblance is active,the imblance is inactive"
      TEXTLINE "                           "
      BITFLD.LONG 0x00 3. "  ADC3_IMBP_BYPASS_3  , define the ADC3 process function in the WCDMA mode. 0:the imblance is active 1:the imblance is inactive" "the imblance is active,the imblance is inactive"
      BITFLD.LONG 0x00 2. "                         ADC3_IMBP_BYPASS_2  , define the ADC3 process function in the GSM mode of the WTG sub-system. 0:the imblance is active 1:the imblance is inactive" "the imblance is active,the imblance is inactive"
      BITFLD.LONG 0x00 1. "                         ADC3_IMBP_BYPASS_1  , define the ADC3 process function in TDSCDMA mode. 0:the imblance is active 1:the imblance is inactive" "the imblance is active,the imblance is inactive"
      BITFLD.LONG 0x00 0. "                         ADC3_IMBP_BYPASS_0  , define the ADC3 process function in the LTE mode. 0:the imblance is active 1:the imblance is inactive" "the imblance is active,the imblance is inactive"
      TEXTLINE "                           "
  GROUP.LONG 0x1F0++0x3 "0x02070000 + 0x1F0"
    LINE.LONG 0x00 "MDAR_IMB_CFG31"
      BITFLD.LONG 0x00 30.--31. "  Reserved , Reserved." "Reserved,Reserved,Reserved,Reserved"
      BITFLD.LONG 0x00 16.--29. "  ADC3_BAL_B , the imblance process parameter B for ADC3" "none"
      BITFLD.LONG 0x00 14.--15. "  Reserved , Reserved." "Reserved,Reserved,Reserved,Reserved"
      BITFLD.LONG 0x00 0.--13. "  ADC3_BAL_A , the imblance process parameter A for ADC3" "none"
      TEXTLINE "                           "
  GROUP.LONG 0x1F4++0x3 "0x02070000 + 0x1F4"
    LINE.LONG 0x00 "MDAR_IMB_CFG32"
      BITFLD.LONG 0x00 30.--31. "  Reserved , Reserved." "Reserved,Reserved,Reserved,Reserved"
      BITFLD.LONG 0x00 16.--29. "  ADC3_BAL_D , the imblance process parameter D for ADC3" "none"
      BITFLD.LONG 0x00 14.--15. "  Reserved , Reserved." "Reserved,Reserved,Reserved,Reserved"
      BITFLD.LONG 0x00 0.--13. "  ADC3_BAL_C , the imblance process parameter C for ADC3" "none"
      TEXTLINE "                           "
  GROUP.LONG 0x1F8++0x3 "0x02070000 + 0x1F8"
    LINE.LONG 0x00 "MDAR_IMB_CFG33"
      BITFLD.LONG 0x00 30.--31. "  Reserved , Reserved." "Reserved,Reserved,Reserved,Reserved"
      BITFLD.LONG 0x00 16.--29. "  DAC3_BAL_B , the imblance process parameter B for DAC3" "none"
      BITFLD.LONG 0x00 14.--15. "  Reserved , Reserved." "Reserved,Reserved,Reserved,Reserved"
      BITFLD.LONG 0x00 0.--13. "  DAC3_BAL_A , the imblance process parameter A for DAC3" "none"
      TEXTLINE "                           "
  GROUP.LONG 0x1FC++0x3 "0x02070000 + 0x1FC"
    LINE.LONG 0x00 "MDAR_IMB_CFG34"
      BITFLD.LONG 0x00 30.--31. "  Reserved , Reserved." "Reserved,Reserved,Reserved,Reserved"
      BITFLD.LONG 0x00 16.--29. "  DAC3_BAL_D , the imblance process parameter D for DAC3" "none"
      BITFLD.LONG 0x00 14.--15. "  Reserved , Reserved." "Reserved,Reserved,Reserved,Reserved"
      BITFLD.LONG 0x00 0.--13. "  DAC3_BAL_C , the imblance process parameter C for DAC3" "none"
      TEXTLINE "                           "
TREE.END
